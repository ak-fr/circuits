* Coriolis Structural SPICE Driver
* Generated on Apr 10, 2025, 00:19
* Cell/Subckt "expmob1_r".
*
* INTERF vss
* INTERF vdd
* INTERF outputs[9]
* INTERF outputs[8]
* INTERF outputs[7]
* INTERF outputs[6]
* INTERF outputs[5]
* INTERF outputs[4]
* INTERF outputs[31]
* INTERF outputs[30]
* INTERF outputs[3]
* INTERF outputs[29]
* INTERF outputs[28]
* INTERF outputs[27]
* INTERF outputs[26]
* INTERF outputs[25]
* INTERF outputs[24]
* INTERF outputs[23]
* INTERF outputs[22]
* INTERF outputs[21]
* INTERF outputs[20]
* INTERF outputs[2]
* INTERF outputs[19]
* INTERF outputs[18]
* INTERF outputs[17]
* INTERF outputs[16]
* INTERF outputs[15]
* INTERF outputs[14]
* INTERF outputs[13]
* INTERF outputs[12]
* INTERF outputs[11]
* INTERF outputs[10]
* INTERF outputs[1]
* INTERF inputs[9]
* INTERF inputs[8]
* INTERF inputs[7]
* INTERF inputs[6]
* INTERF inputs[5]
* INTERF inputs[4]
* INTERF inputs[31]
* INTERF inputs[30]
* INTERF inputs[3]
* INTERF inputs[29]
* INTERF inputs[28]
* INTERF inputs[27]
* INTERF inputs[26]
* INTERF inputs[25]
* INTERF inputs[24]
* INTERF inputs[23]
* INTERF inputs[22]
* INTERF inputs[21]
* INTERF inputs[20]
* INTERF inputs[2]
* INTERF inputs[19]
* INTERF inputs[18]
* INTERF inputs[17]
* INTERF inputs[16]
* INTERF inputs[15]
* INTERF inputs[14]
* INTERF inputs[13]
* INTERF inputs[12]
* INTERF inputs[11]
* INTERF inputs[10]
* INTERF inputs[1]
* INTERF inputs[0]

* Terminal models (aka standard cells) used througout all the hierarchy.
.include decap_w0.spi
.include tie.spi
.include inv_x0.spi
.include nexor2_x0.spi
.include xor2_x0.spi
.include diode_w1.spi

* Non-terminal models (part of the user's design hierarchy).

.subckt expmob1_r 0 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63 64
* NET     0 = vss
* NET     1 = vdd
* NET     2 = outputs[9]
* NET     3 = outputs[8]
* NET     4 = outputs[7]
* NET     5 = outputs[6]
* NET     6 = outputs[5]
* NET     7 = outputs[4]
* NET     8 = outputs[31]
* NET     9 = outputs[30]
* NET    10 = outputs[3]
* NET    11 = outputs[29]
* NET    12 = outputs[28]
* NET    13 = outputs[27]
* NET    14 = outputs[26]
* NET    15 = outputs[25]
* NET    16 = outputs[24]
* NET    17 = outputs[23]
* NET    18 = outputs[22]
* NET    19 = outputs[21]
* NET    20 = outputs[20]
* NET    21 = outputs[2]
* NET    22 = outputs[19]
* NET    23 = outputs[18]
* NET    24 = outputs[17]
* NET    25 = outputs[16]
* NET    26 = outputs[15]
* NET    27 = outputs[14]
* NET    28 = outputs[13]
* NET    29 = outputs[12]
* NET    30 = outputs[11]
* NET    31 = outputs[10]
* NET    32 = outputs[1]
* NET    33 = inputs[9]
* NET    34 = inputs[8]
* NET    35 = inputs[7]
* NET    36 = inputs[6]
* NET    37 = inputs[5]
* NET    38 = inputs[4]
* NET    39 = inputs[31]
* NET    40 = inputs[30]
* NET    41 = inputs[3]
* NET    42 = inputs[29]
* NET    43 = inputs[28]
* NET    44 = inputs[27]
* NET    45 = inputs[26]
* NET    46 = inputs[25]
* NET    47 = inputs[24]
* NET    48 = inputs[23]
* NET    49 = inputs[22]
* NET    50 = inputs[21]
* NET    51 = inputs[20]
* NET    52 = inputs[2]
* NET    53 = inputs[19]
* NET    54 = inputs[18]
* NET    55 = inputs[17]
* NET    56 = inputs[16]
* NET    57 = inputs[15]
* NET    58 = inputs[14]
* NET    59 = inputs[13]
* NET    60 = inputs[12]
* NET    61 = inputs[11]
* NET    62 = inputs[10]
* NET    63 = inputs[1]
* NET    64 = inputs[0]
* NET    65 = genblk1_3_si_outputs_7
* NET    66 = genblk1_3_si_outputs_31
* NET    67 = genblk1_3_si_outputs_3
* NET    68 = genblk1_3_si_outputs_27
* NET    69 = genblk1_3_si_outputs_23
* NET    70 = genblk1_3_si_outputs_19
* NET    71 = genblk1_3_si_outputs_15
* NET    72 = genblk1_3_si_outputs_11
* NET    73 = genblk1_2_si_outputs_7
* NET    74 = genblk1_2_si_outputs_6
* NET    75 = genblk1_2_si_outputs_5
* NET    76 = genblk1_2_si_outputs_31
* NET    77 = genblk1_2_si_outputs_30
* NET    78 = genblk1_2_si_outputs_29
* NET    79 = genblk1_2_si_outputs_23
* NET    80 = genblk1_2_si_outputs_22
* NET    81 = genblk1_2_si_outputs_21
* NET    82 = genblk1_2_si_outputs_15
* NET    83 = genblk1_2_si_outputs_14
* NET    84 = genblk1_2_si_outputs_13
* NET    85 = genblk1_1_si_outputs_9
* NET    86 = genblk1_1_si_outputs_31
* NET    87 = genblk1_1_si_outputs_30
* NET    88 = genblk1_1_si_outputs_29
* NET    89 = genblk1_1_si_outputs_28
* NET    90 = genblk1_1_si_outputs_27
* NET    91 = genblk1_1_si_outputs_26
* NET    92 = genblk1_1_si_outputs_25
* NET    93 = genblk1_1_si_outputs_15
* NET    94 = genblk1_1_si_outputs_14
* NET    95 = genblk1_1_si_outputs_13
* NET    96 = genblk1_1_si_outputs_12
* NET    97 = genblk1_1_si_outputs_11
* NET    98 = genblk1_1_si_outputs_10
* NET    99 = genblk1_1_si_inputs_31
* NET   100 = genblk1_1_si_inputs_30
* NET   101 = genblk1_1_si_inputs_29
* NET   102 = genblk1_1_si_inputs_28
* NET   103 = genblk1_1_si_inputs_27
* NET   104 = genblk1_1_si_inputs_26
* NET   105 = genblk1_1_si_inputs_25
* NET   106 = genblk1_1_si_inputs_24
* NET   107 = genblk1_1_si_inputs_23
* NET   108 = genblk1_1_si_inputs_22
* NET   109 = genblk1_1_si_inputs_21
* NET   110 = genblk1_1_si_inputs_20
* NET   111 = genblk1_1_si_inputs_19
* NET   112 = genblk1_1_si_inputs_18
* NET   113 = genblk1_1_si_inputs_17
* NET   114 = blockagenet
* NET   115 = abc_355_new_n99
* NET   116 = abc_355_new_n98
* NET   117 = abc_355_new_n96
* NET   118 = abc_355_new_n95
* NET   119 = abc_355_new_n93
* NET   120 = abc_355_new_n92
* NET   121 = abc_355_new_n91
* NET   122 = abc_355_new_n90
* NET   123 = abc_355_new_n88
* NET   124 = abc_355_new_n87
* NET   125 = abc_355_new_n86
* NET   126 = abc_355_new_n84
* NET   127 = abc_355_new_n83
* NET   128 = abc_355_new_n81
* NET   129 = abc_355_new_n79
* NET   130 = abc_355_new_n78
* NET   131 = abc_355_new_n76
* NET   132 = abc_355_new_n75
* NET   133 = abc_355_new_n73
* NET   134 = abc_355_new_n72
* NET   135 = abc_355_new_n69
* NET   136 = abc_355_new_n68
* NET   137 = abc_355_new_n66
* NET   138 = abc_355_new_n64
* NET   139 = abc_355_new_n163
* NET   140 = abc_355_new_n162
* NET   141 = abc_355_new_n161
* NET   142 = abc_355_new_n160
* NET   143 = abc_355_new_n158
* NET   144 = abc_355_new_n157
* NET   145 = abc_355_new_n156
* NET   146 = abc_355_new_n154
* NET   147 = abc_355_new_n153
* NET   148 = abc_355_new_n152
* NET   149 = abc_355_new_n150
* NET   150 = abc_355_new_n149
* NET   151 = abc_355_new_n148
* NET   152 = abc_355_new_n146
* NET   153 = abc_355_new_n145
* NET   154 = abc_355_new_n144
* NET   155 = abc_355_new_n142
* NET   156 = abc_355_new_n141
* NET   157 = abc_355_new_n140
* NET   158 = abc_355_new_n138
* NET   159 = abc_355_new_n137
* NET   160 = abc_355_new_n135
* NET   161 = abc_355_new_n134
* NET   162 = abc_355_new_n132
* NET   163 = abc_355_new_n131
* NET   164 = abc_355_new_n130
* NET   165 = abc_355_new_n129
* NET   166 = abc_355_new_n127
* NET   167 = abc_355_new_n126
* NET   168 = abc_355_new_n125
* NET   169 = abc_355_new_n123
* NET   170 = abc_355_new_n122
* NET   171 = abc_355_new_n121
* NET   172 = abc_355_new_n119
* NET   173 = abc_355_new_n118
* NET   174 = abc_355_new_n116
* NET   175 = abc_355_new_n115
* NET   176 = abc_355_new_n113
* NET   177 = abc_355_new_n111
* NET   178 = abc_355_new_n109
* NET   179 = abc_355_new_n107
* NET   180 = abc_355_new_n106
* NET   181 = abc_355_new_n105
* NET   182 = abc_355_new_n103
* NET   183 = abc_355_new_n102
* NET   184 = abc_355_new_n101

xfeed_29239 1 0 decap_w0
xfeed_29238 1 0 decap_w0
xfeed_29237 1 0 decap_w0
xfeed_29236 1 0 decap_w0
xfeed_29235 1 0 decap_w0
xfeed_29234 1 0 decap_w0
xfeed_29233 1 0 decap_w0
xfeed_29232 1 0 decap_w0
xfeed_29231 1 0 decap_w0
xfeed_29230 1 0 decap_w0
xfeed_28709 1 0 decap_w0
xfeed_28708 1 0 decap_w0
xfeed_28707 1 0 decap_w0
xfeed_28706 1 0 decap_w0
xfeed_28705 1 0 decap_w0
xfeed_28704 1 0 decap_w0
xfeed_28703 1 0 decap_w0
xfeed_28702 1 0 decap_w0
xfeed_28701 1 0 decap_w0
xfeed_28700 1 0 decap_w0
xfeed_23786 1 0 decap_w0
xfeed_23785 1 0 decap_w0
xfeed_23784 1 0 decap_w0
xfeed_23783 1 0 decap_w0
xfeed_23782 1 0 decap_w0
xfeed_23781 1 0 decap_w0
xfeed_23780 1 0 decap_w0
xfeed_6739 1 0 decap_w0
xfeed_6738 1 0 decap_w0
xfeed_6737 1 0 decap_w0
xfeed_6736 1 0 decap_w0
xfeed_6735 1 0 decap_w0
xfeed_6734 1 0 decap_w0
xfeed_6733 1 0 decap_w0
xfeed_6732 1 0 decap_w0
xfeed_6731 1 0 decap_w0
xfeed_409 1 0 decap_w0
xfeed_408 1 0 decap_w0
xfeed_407 1 0 decap_w0
xfeed_406 1 0 decap_w0
xfeed_405 1 0 decap_w0
xfeed_404 1 0 decap_w0
xfeed_403 1 0 decap_w0
xfeed_402 1 0 decap_w0
xfeed_401 1 0 decap_w0
xfeed_400 1 0 decap_w0
xfeed_23789 1 0 decap_w0
xfeed_23788 1 0 decap_w0
xfeed_23787 1 0 decap_w0
xfeed_17789 1 0 decap_w0
xfeed_17788 1 0 decap_w0
xfeed_17787 1 0 decap_w0
xfeed_17786 1 0 decap_w0
xfeed_17785 1 0 decap_w0
xfeed_17784 1 0 decap_w0
xfeed_17783 1 0 decap_w0
xfeed_17782 1 0 decap_w0
xfeed_17781 1 0 decap_w0
xfeed_17780 1 0 decap_w0
xfeed_13479 1 0 decap_w0
xfeed_13478 1 0 decap_w0
xfeed_13477 1 0 decap_w0
xfeed_13476 1 0 decap_w0
xfeed_13475 1 0 decap_w0
xfeed_13474 1 0 decap_w0
xfeed_13473 1 0 decap_w0
xfeed_13472 1 0 decap_w0
xfeed_13471 1 0 decap_w0
xfeed_13470 1 0 decap_w0
xfeed_12949 1 0 decap_w0
xfeed_12948 1 0 decap_w0
xfeed_12947 1 0 decap_w0
xfeed_12946 1 0 decap_w0
xfeed_12945 1 0 decap_w0
xfeed_12944 1 0 decap_w0
xfeed_12943 1 0 decap_w0
xfeed_12942 1 0 decap_w0
xfeed_12941 1 0 decap_w0
xfeed_12940 1 0 decap_w0
xfeed_7276 1 0 decap_w0
xfeed_7275 1 0 decap_w0
xfeed_7274 1 0 decap_w0
xfeed_7273 1 0 decap_w0
xfeed_7272 1 0 decap_w0
xfeed_7271 1 0 decap_w0
xfeed_7270 1 0 decap_w0
xfeed_2437 1 0 decap_w0
xfeed_2436 1 0 decap_w0
xfeed_2435 1 0 decap_w0
xfeed_2434 1 0 decap_w0
xfeed_2433 1 0 decap_w0
xfeed_2432 1 0 decap_w0
xfeed_2431 1 0 decap_w0
xfeed_2430 1 0 decap_w0
xfeed_30409 1 0 decap_w0
xfeed_30408 1 0 decap_w0
xfeed_30407 1 0 decap_w0
xfeed_30406 1 0 decap_w0
xfeed_30405 1 0 decap_w0
xfeed_30404 1 0 decap_w0
xfeed_30403 1 0 decap_w0
xfeed_30402 1 0 decap_w0
xfeed_30401 1 0 decap_w0
xfeed_30400 1 0 decap_w0
xfeed_29249 1 0 decap_w0
xfeed_29248 1 0 decap_w0
xfeed_29247 1 0 decap_w0
xfeed_29246 1 0 decap_w0
xfeed_29245 1 0 decap_w0
xfeed_29244 1 0 decap_w0
xfeed_29243 1 0 decap_w0
xfeed_29242 1 0 decap_w0
xfeed_29241 1 0 decap_w0
xfeed_29240 1 0 decap_w0
xfeed_28719 1 0 decap_w0
xfeed_28718 1 0 decap_w0
xfeed_28717 1 0 decap_w0
xfeed_28716 1 0 decap_w0
xfeed_28715 1 0 decap_w0
xfeed_28714 1 0 decap_w0
xfeed_28713 1 0 decap_w0
xfeed_28712 1 0 decap_w0
xfeed_28711 1 0 decap_w0
xfeed_28710 1 0 decap_w0
xfeed_24409 1 0 decap_w0
xfeed_24408 1 0 decap_w0
xfeed_24407 1 0 decap_w0
xfeed_24406 1 0 decap_w0
xfeed_24405 1 0 decap_w0
xfeed_24404 1 0 decap_w0
xfeed_24403 1 0 decap_w0
xfeed_24402 1 0 decap_w0
xfeed_24401 1 0 decap_w0
xfeed_24400 1 0 decap_w0
xfeed_23793 1 0 decap_w0
xfeed_23792 1 0 decap_w0
xfeed_23791 1 0 decap_w0
xfeed_23790 1 0 decap_w0
xfeed_18403 1 0 decap_w0
xfeed_18402 1 0 decap_w0
xfeed_18401 1 0 decap_w0
xfeed_18400 1 0 decap_w0
xfeed_7279 1 0 decap_w0
xfeed_7278 1 0 decap_w0
xfeed_7277 1 0 decap_w0
xfeed_6749 1 0 decap_w0
xfeed_6748 1 0 decap_w0
xfeed_6747 1 0 decap_w0
xfeed_6746 1 0 decap_w0
xfeed_6745 1 0 decap_w0
xfeed_6744 1 0 decap_w0
xfeed_6743 1 0 decap_w0
xfeed_6742 1 0 decap_w0
xfeed_6741 1 0 decap_w0
xfeed_6740 1 0 decap_w0
xfeed_2439 1 0 decap_w0
xfeed_2438 1 0 decap_w0
xfeed_419 1 0 decap_w0
xfeed_418 1 0 decap_w0
xfeed_417 1 0 decap_w0
xfeed_416 1 0 decap_w0
xfeed_415 1 0 decap_w0
xfeed_414 1 0 decap_w0
xfeed_413 1 0 decap_w0
xfeed_412 1 0 decap_w0
xfeed_411 1 0 decap_w0
xfeed_410 1 0 decap_w0
xfeed_1900 1 0 decap_w0
xfeed_1901 1 0 decap_w0
xfeed_1902 1 0 decap_w0
xfeed_1903 1 0 decap_w0
xfeed_1904 1 0 decap_w0
xfeed_1905 1 0 decap_w0
xfeed_1906 1 0 decap_w0
xfeed_1907 1 0 decap_w0
xfeed_1908 1 0 decap_w0
xfeed_1909 1 0 decap_w0
xfeed_23799 1 0 decap_w0
xfeed_23798 1 0 decap_w0
xfeed_23797 1 0 decap_w0
xfeed_23796 1 0 decap_w0
xfeed_23795 1 0 decap_w0
xfeed_23794 1 0 tie
xfeed_18409 1 0 decap_w0
xfeed_18408 1 0 decap_w0
xfeed_18407 1 0 decap_w0
xfeed_18406 1 0 decap_w0
xfeed_18405 1 0 decap_w0
xfeed_18404 1 0 decap_w0
xfeed_17799 1 0 decap_w0
xfeed_17798 1 0 decap_w0
xfeed_17797 1 0 decap_w0
xfeed_17796 1 0 decap_w0
xfeed_17795 1 0 decap_w0
xfeed_17794 1 0 decap_w0
xfeed_17793 1 0 decap_w0
xfeed_17792 1 0 decap_w0
xfeed_17791 1 0 decap_w0
xfeed_17790 1 0 decap_w0
xfeed_13489 1 0 decap_w0
xfeed_13488 1 0 decap_w0
xfeed_13487 1 0 decap_w0
xfeed_13486 1 0 decap_w0
xfeed_13485 1 0 decap_w0
xfeed_13484 1 0 decap_w0
xfeed_13483 1 0 decap_w0
xfeed_13482 1 0 decap_w0
xfeed_13481 1 0 decap_w0
xfeed_13480 1 0 decap_w0
xfeed_12959 1 0 decap_w0
xfeed_12958 1 0 decap_w0
xfeed_12957 1 0 decap_w0
xfeed_12956 1 0 decap_w0
xfeed_12955 1 0 decap_w0
xfeed_12954 1 0 decap_w0
xfeed_12953 1 0 decap_w0
xfeed_12952 1 0 decap_w0
xfeed_12951 1 0 decap_w0
xfeed_12950 1 0 decap_w0
xfeed_7283 1 0 decap_w0
xfeed_7282 1 0 decap_w0
xfeed_7281 1 0 decap_w0
xfeed_7280 1 0 decap_w0
xfeed_2444 1 0 decap_w0
xfeed_2443 1 0 decap_w0
xfeed_2442 1 0 decap_w0
xfeed_2441 1 0 decap_w0
xfeed_2440 1 0 decap_w0
xfeed_30419 1 0 decap_w0
xfeed_30418 1 0 decap_w0
xfeed_30417 1 0 decap_w0
xfeed_30416 1 0 decap_w0
xfeed_30415 1 0 decap_w0
xfeed_30414 1 0 decap_w0
xfeed_30413 1 0 decap_w0
xfeed_30412 1 0 decap_w0
xfeed_30411 1 0 decap_w0
xfeed_30410 1 0 decap_w0
xfeed_29259 1 0 decap_w0
xfeed_29258 1 0 decap_w0
xfeed_29257 1 0 decap_w0
xfeed_29256 1 0 decap_w0
xfeed_29255 1 0 decap_w0
xfeed_29254 1 0 decap_w0
xfeed_29253 1 0 decap_w0
xfeed_29252 1 0 decap_w0
xfeed_29251 1 0 decap_w0
xfeed_29250 1 0 decap_w0
xfeed_28729 1 0 decap_w0
xfeed_28728 1 0 decap_w0
xfeed_28727 1 0 decap_w0
xfeed_28726 1 0 decap_w0
xfeed_28725 1 0 decap_w0
xfeed_28724 1 0 decap_w0
xfeed_28723 1 0 decap_w0
xfeed_28722 1 0 decap_w0
xfeed_28721 1 0 decap_w0
xfeed_28720 1 0 decap_w0
xfeed_24419 1 0 decap_w0
xfeed_24418 1 0 decap_w0
xfeed_24417 1 0 decap_w0
xfeed_24416 1 0 decap_w0
xfeed_24415 1 0 decap_w0
xfeed_24414 1 0 decap_w0
xfeed_24413 1 0 decap_w0
xfeed_24412 1 0 decap_w0
xfeed_24411 1 0 decap_w0
xfeed_24410 1 0 decap_w0
xfeed_20109 1 0 decap_w0
xfeed_20108 1 0 decap_w0
xfeed_20107 1 0 decap_w0
xfeed_20106 1 0 decap_w0
xfeed_20105 1 0 decap_w0
xfeed_20104 1 0 decap_w0
xfeed_20103 1 0 decap_w0
xfeed_20102 1 0 decap_w0
xfeed_20101 1 0 decap_w0
xfeed_20100 1 0 decap_w0
xfeed_18410 1 0 decap_w0
xfeed_14109 1 0 decap_w0
xfeed_14108 1 0 decap_w0
xfeed_14107 1 0 decap_w0
xfeed_14106 1 0 decap_w0
xfeed_14105 1 0 decap_w0
xfeed_14104 1 0 decap_w0
xfeed_14103 1 0 decap_w0
xfeed_14102 1 0 decap_w0
xfeed_14101 1 0 decap_w0
xfeed_14100 1 0 decap_w0
xfeed_7289 1 0 decap_w0
xfeed_7288 1 0 decap_w0
xfeed_7287 1 0 decap_w0
xfeed_7286 1 0 decap_w0
xfeed_7285 1 0 decap_w0
xfeed_7284 1 0 decap_w0
xfeed_6759 1 0 decap_w0
xfeed_6758 1 0 decap_w0
xfeed_6757 1 0 decap_w0
xfeed_6756 1 0 decap_w0
xfeed_6755 1 0 decap_w0
xfeed_6754 1 0 decap_w0
xfeed_6753 1 0 decap_w0
xfeed_6752 1 0 decap_w0
xfeed_6751 1 0 decap_w0
xfeed_6750 1 0 decap_w0
xfeed_2449 1 0 decap_w0
xfeed_2448 1 0 decap_w0
xfeed_2447 1 0 decap_w0
xfeed_2446 1 0 decap_w0
xfeed_2445 1 0 decap_w0
xfeed_429 1 0 decap_w0
xfeed_428 1 0 decap_w0
xfeed_427 1 0 decap_w0
xfeed_426 1 0 decap_w0
xfeed_425 1 0 decap_w0
xfeed_424 1 0 decap_w0
xfeed_423 1 0 decap_w0
xfeed_422 1 0 decap_w0
xfeed_421 1 0 decap_w0
xfeed_420 1 0 decap_w0
xfeed_1910 1 0 decap_w0
xfeed_1911 1 0 decap_w0
xfeed_1912 1 0 decap_w0
xfeed_1913 1 0 decap_w0
xfeed_1914 1 0 decap_w0
xfeed_1915 1 0 decap_w0
xfeed_1916 1 0 decap_w0
xfeed_1917 1 0 decap_w0
xfeed_1918 1 0 decap_w0
xfeed_1919 1 0 decap_w0
xfeed_18419 1 0 decap_w0
xfeed_18418 1 0 decap_w0
xfeed_18417 1 0 decap_w0
xfeed_18416 1 0 decap_w0
xfeed_18415 1 0 decap_w0
xfeed_18414 1 0 decap_w0
xfeed_18413 1 0 decap_w0
xfeed_18412 1 0 decap_w0
xfeed_18411 1 0 decap_w0
xfeed_13499 1 0 decap_w0
xfeed_13498 1 0 decap_w0
xfeed_13497 1 0 decap_w0
xfeed_13496 1 0 decap_w0
xfeed_13495 1 0 decap_w0
xfeed_13494 1 0 decap_w0
xfeed_13493 1 0 decap_w0
xfeed_13492 1 0 decap_w0
xfeed_13491 1 0 decap_w0
xfeed_13490 1 0 decap_w0
xfeed_12969 1 0 decap_w0
xfeed_12968 1 0 decap_w0
xfeed_12967 1 0 decap_w0
xfeed_12966 1 0 decap_w0
xfeed_12965 1 0 decap_w0
xfeed_12964 1 0 decap_w0
xfeed_12963 1 0 decap_w0
xfeed_12962 1 0 decap_w0
xfeed_12961 1 0 decap_w0
xfeed_12960 1 0 decap_w0
xfeed_7290 1 0 decap_w0
xfeed_2451 1 0 decap_w0
xfeed_2450 1 0 decap_w0
xfeed_30429 1 0 decap_w0
xfeed_30428 1 0 decap_w0
xfeed_30427 1 0 decap_w0
xfeed_30426 1 0 decap_w0
xfeed_30425 1 0 decap_w0
xfeed_30424 1 0 decap_w0
xfeed_30423 1 0 decap_w0
xfeed_30422 1 0 decap_w0
xfeed_30421 1 0 decap_w0
xfeed_30420 1 0 decap_w0
xfeed_29269 1 0 decap_w0
xfeed_29268 1 0 decap_w0
xfeed_29267 1 0 decap_w0
xfeed_29266 1 0 decap_w0
xfeed_29265 1 0 decap_w0
xfeed_29264 1 0 decap_w0
xfeed_29263 1 0 decap_w0
xfeed_29262 1 0 decap_w0
xfeed_29261 1 0 decap_w0
xfeed_29260 1 0 decap_w0
xfeed_28739 1 0 decap_w0
xfeed_28738 1 0 decap_w0
xfeed_28737 1 0 decap_w0
xfeed_28736 1 0 decap_w0
xfeed_28735 1 0 decap_w0
xfeed_28734 1 0 decap_w0
xfeed_28733 1 0 decap_w0
xfeed_28732 1 0 decap_w0
xfeed_28731 1 0 decap_w0
xfeed_28730 1 0 decap_w0
xfeed_24429 1 0 decap_w0
xfeed_24428 1 0 decap_w0
xfeed_24427 1 0 decap_w0
xfeed_24426 1 0 decap_w0
xfeed_24425 1 0 decap_w0
xfeed_24424 1 0 decap_w0
xfeed_24423 1 0 decap_w0
xfeed_24422 1 0 decap_w0
xfeed_24421 1 0 decap_w0
xfeed_24420 1 0 decap_w0
xfeed_20119 1 0 decap_w0
xfeed_20118 1 0 decap_w0
xfeed_20117 1 0 decap_w0
xfeed_20116 1 0 decap_w0
xfeed_20115 1 0 decap_w0
xfeed_20114 1 0 decap_w0
xfeed_20113 1 0 decap_w0
xfeed_20112 1 0 decap_w0
xfeed_20111 1 0 decap_w0
xfeed_20110 1 0 decap_w0
xfeed_14117 1 0 decap_w0
xfeed_14116 1 0 decap_w0
xfeed_14115 1 0 decap_w0
xfeed_14114 1 0 decap_w0
xfeed_14113 1 0 decap_w0
xfeed_14112 1 0 decap_w0
xfeed_14111 1 0 decap_w0
xfeed_14110 1 0 decap_w0
xfeed_7299 1 0 decap_w0
xfeed_7298 1 0 decap_w0
xfeed_7297 1 0 decap_w0
xfeed_7296 1 0 decap_w0
xfeed_7295 1 0 decap_w0
xfeed_7294 1 0 decap_w0
xfeed_7293 1 0 decap_w0
xfeed_7292 1 0 decap_w0
xfeed_7291 1 0 decap_w0
xfeed_6769 1 0 decap_w0
xfeed_6768 1 0 decap_w0
xfeed_6767 1 0 decap_w0
xfeed_6766 1 0 decap_w0
xfeed_6765 1 0 decap_w0
xfeed_6764 1 0 decap_w0
xfeed_6763 1 0 decap_w0
xfeed_6762 1 0 decap_w0
xfeed_6761 1 0 decap_w0
xfeed_6760 1 0 decap_w0
xfeed_2459 1 0 decap_w0
xfeed_2458 1 0 decap_w0
xfeed_2457 1 0 decap_w0
xfeed_2456 1 0 decap_w0
xfeed_2455 1 0 decap_w0
xfeed_2454 1 0 decap_w0
xfeed_2453 1 0 decap_w0
xfeed_2452 1 0 decap_w0
xfeed_439 1 0 decap_w0
xfeed_438 1 0 decap_w0
xfeed_437 1 0 decap_w0
xfeed_436 1 0 decap_w0
xfeed_435 1 0 decap_w0
xfeed_434 1 0 decap_w0
xfeed_433 1 0 decap_w0
xfeed_432 1 0 decap_w0
xfeed_431 1 0 decap_w0
xfeed_430 1 0 decap_w0
xfeed_1920 1 0 decap_w0
xfeed_1921 1 0 decap_w0
xfeed_1922 1 0 decap_w0
xfeed_1923 1 0 decap_w0
xfeed_1924 1 0 decap_w0
xfeed_1925 1 0 decap_w0
xfeed_1926 1 0 decap_w0
xfeed_1927 1 0 decap_w0
xfeed_1928 1 0 decap_w0
xfeed_1929 1 0 decap_w0
xfeed_18429 1 0 decap_w0
xfeed_18428 1 0 decap_w0
xfeed_18427 1 0 decap_w0
xfeed_18426 1 0 decap_w0
xfeed_18425 1 0 decap_w0
xfeed_18424 1 0 decap_w0
xfeed_18423 1 0 decap_w0
xfeed_18422 1 0 decap_w0
xfeed_18421 1 0 decap_w0
xfeed_18420 1 0 decap_w0
xfeed_14119 1 0 decap_w0
xfeed_14118 1 0 decap_w0
xfeed_12979 1 0 decap_w0
xfeed_12978 1 0 decap_w0
xfeed_12977 1 0 decap_w0
xfeed_12976 1 0 decap_w0
xfeed_12975 1 0 decap_w0
xfeed_12974 1 0 decap_w0
xfeed_12973 1 0 decap_w0
xfeed_12972 1 0 decap_w0
xfeed_12971 1 0 decap_w0
xfeed_12970 1 0 decap_w0
xfeed_30439 1 0 decap_w0
xfeed_30438 1 0 decap_w0
xfeed_30437 1 0 decap_w0
xfeed_30436 1 0 decap_w0
xfeed_30435 1 0 decap_w0
xfeed_30434 1 0 decap_w0
xfeed_30433 1 0 decap_w0
xfeed_30432 1 0 decap_w0
xfeed_30431 1 0 decap_w0
xfeed_30430 1 0 decap_w0
xfeed_29279 1 0 decap_w0
xfeed_29278 1 0 decap_w0
xfeed_29277 1 0 decap_w0
xfeed_29276 1 0 decap_w0
xfeed_29275 1 0 decap_w0
xfeed_29274 1 0 decap_w0
xfeed_29273 1 0 decap_w0
xfeed_29272 1 0 decap_w0
xfeed_29271 1 0 decap_w0
xfeed_29270 1 0 decap_w0
xfeed_28749 1 0 decap_w0
xfeed_28748 1 0 decap_w0
xfeed_28747 1 0 decap_w0
xfeed_28746 1 0 decap_w0
xfeed_28745 1 0 decap_w0
xfeed_28744 1 0 decap_w0
xfeed_28743 1 0 decap_w0
xfeed_28742 1 0 decap_w0
xfeed_28741 1 0 decap_w0
xfeed_28740 1 0 decap_w0
xfeed_24439 1 0 decap_w0
xfeed_24438 1 0 decap_w0
xfeed_24437 1 0 decap_w0
xfeed_24436 1 0 decap_w0
xfeed_24435 1 0 decap_w0
xfeed_24434 1 0 decap_w0
xfeed_24433 1 0 decap_w0
xfeed_24432 1 0 decap_w0
xfeed_24431 1 0 decap_w0
xfeed_24430 1 0 decap_w0
xfeed_23909 1 0 decap_w0
xfeed_23908 1 0 decap_w0
xfeed_23907 1 0 decap_w0
xfeed_23906 1 0 decap_w0
xfeed_23905 1 0 decap_w0
xfeed_23904 1 0 decap_w0
xfeed_23903 1 0 decap_w0
xfeed_23902 1 0 decap_w0
xfeed_23901 1 0 decap_w0
xfeed_23900 1 0 decap_w0
xfeed_20129 1 0 decap_w0
xfeed_20128 1 0 decap_w0
xfeed_20127 1 0 decap_w0
xfeed_20126 1 0 decap_w0
xfeed_20125 1 0 decap_w0
xfeed_20124 1 0 decap_w0
xfeed_20123 1 0 decap_w0
xfeed_20122 1 0 decap_w0
xfeed_20121 1 0 decap_w0
xfeed_20120 1 0 decap_w0
xfeed_14124 1 0 decap_w0
xfeed_14123 1 0 decap_w0
xfeed_14122 1 0 decap_w0
xfeed_14121 1 0 decap_w0
xfeed_14120 1 0 decap_w0
xfeed_6779 1 0 decap_w0
xfeed_6778 1 0 decap_w0
xfeed_6777 1 0 decap_w0
xfeed_6776 1 0 decap_w0
xfeed_6775 1 0 decap_w0
xfeed_6774 1 0 decap_w0
xfeed_6773 1 0 decap_w0
xfeed_6772 1 0 decap_w0
xfeed_6771 1 0 decap_w0
xfeed_6770 1 0 decap_w0
xfeed_2469 1 0 decap_w0
xfeed_2468 1 0 decap_w0
xfeed_2467 1 0 decap_w0
xfeed_2466 1 0 decap_w0
xfeed_2465 1 0 decap_w0
xfeed_2464 1 0 decap_w0
xfeed_2463 1 0 decap_w0
xfeed_2462 1 0 decap_w0
xfeed_2461 1 0 decap_w0
xfeed_2460 1 0 decap_w0
xfeed_449 1 0 decap_w0
xfeed_448 1 0 decap_w0
xfeed_447 1 0 decap_w0
xfeed_446 1 0 decap_w0
xfeed_445 1 0 decap_w0
xfeed_444 1 0 decap_w0
xfeed_443 1 0 decap_w0
xfeed_442 1 0 decap_w0
xfeed_441 1 0 decap_w0
xfeed_440 1 0 decap_w0
xfeed_1930 1 0 decap_w0
xfeed_1931 1 0 decap_w0
xfeed_1932 1 0 decap_w0
xfeed_1933 1 0 decap_w0
xfeed_1934 1 0 decap_w0
xfeed_1935 1 0 decap_w0
xfeed_1936 1 0 decap_w0
xfeed_1937 1 0 decap_w0
xfeed_1938 1 0 decap_w0
xfeed_1939 1 0 decap_w0
xfeed_18439 1 0 decap_w0
xfeed_18438 1 0 decap_w0
xfeed_18437 1 0 decap_w0
xfeed_18436 1 0 decap_w0
xfeed_18435 1 0 decap_w0
xfeed_18434 1 0 decap_w0
xfeed_18433 1 0 decap_w0
xfeed_18432 1 0 decap_w0
xfeed_18431 1 0 decap_w0
xfeed_18430 1 0 decap_w0
xfeed_17909 1 0 decap_w0
xfeed_17908 1 0 decap_w0
xfeed_17907 1 0 decap_w0
xfeed_17906 1 0 decap_w0
xfeed_17905 1 0 decap_w0
xfeed_17904 1 0 decap_w0
xfeed_17903 1 0 decap_w0
xfeed_17902 1 0 decap_w0
xfeed_17901 1 0 decap_w0
xfeed_17900 1 0 decap_w0
xfeed_14129 1 0 decap_w0
xfeed_14128 1 0 decap_w0
xfeed_14127 1 0 decap_w0
xfeed_14126 1 0 decap_w0
xfeed_14125 1 0 decap_w0
xfeed_12989 1 0 decap_w0
xfeed_12988 1 0 decap_w0
xfeed_12987 1 0 decap_w0
xfeed_12986 1 0 decap_w0
xfeed_12985 1 0 decap_w0
xfeed_12984 1 0 decap_w0
xfeed_12983 1 0 decap_w0
xfeed_12982 1 0 decap_w0
xfeed_12981 1 0 decap_w0
xfeed_12980 1 0 decap_w0
xfeed_30449 1 0 decap_w0
xfeed_30448 1 0 decap_w0
xfeed_30447 1 0 decap_w0
xfeed_30446 1 0 decap_w0
xfeed_30445 1 0 decap_w0
xfeed_30444 1 0 decap_w0
xfeed_30443 1 0 decap_w0
xfeed_30442 1 0 decap_w0
xfeed_30441 1 0 decap_w0
xfeed_30440 1 0 decap_w0
xfeed_29289 1 0 decap_w0
xfeed_29288 1 0 decap_w0
xfeed_29287 1 0 decap_w0
xfeed_29286 1 0 decap_w0
xfeed_29285 1 0 decap_w0
xfeed_29284 1 0 decap_w0
xfeed_29283 1 0 decap_w0
xfeed_29282 1 0 decap_w0
xfeed_29281 1 0 decap_w0
xfeed_29280 1 0 decap_w0
xfeed_28758 1 0 decap_w0
xfeed_28757 1 0 decap_w0
xfeed_28756 1 0 decap_w0
xfeed_28755 1 0 decap_w0
xfeed_28754 1 0 decap_w0
xfeed_28753 1 0 decap_w0
xfeed_28752 1 0 decap_w0
xfeed_28751 1 0 decap_w0
xfeed_28750 1 0 decap_w0
xfeed_24449 1 0 decap_w0
xfeed_24448 1 0 decap_w0
xfeed_24447 1 0 decap_w0
xfeed_24446 1 0 decap_w0
xfeed_24445 1 0 decap_w0
xfeed_24444 1 0 decap_w0
xfeed_24443 1 0 decap_w0
xfeed_24442 1 0 decap_w0
xfeed_24441 1 0 decap_w0
xfeed_24440 1 0 decap_w0
xfeed_23919 1 0 decap_w0
xfeed_23918 1 0 decap_w0
xfeed_23917 1 0 decap_w0
xfeed_23916 1 0 decap_w0
xfeed_23915 1 0 decap_w0
xfeed_23914 1 0 decap_w0
xfeed_23913 1 0 decap_w0
xfeed_23912 1 0 decap_w0
xfeed_23911 1 0 decap_w0
xfeed_23910 1 0 decap_w0
xfeed_20139 1 0 decap_w0
xfeed_20138 1 0 decap_w0
xfeed_20137 1 0 decap_w0
xfeed_20136 1 0 decap_w0
xfeed_20135 1 0 decap_w0
xfeed_20134 1 0 decap_w0
xfeed_20133 1 0 decap_w0
xfeed_20132 1 0 decap_w0
xfeed_20131 1 0 decap_w0
xfeed_20130 1 0 decap_w0
xfeed_14131 1 0 decap_w0
xfeed_14130 1 0 decap_w0
xfeed_6789 1 0 decap_w0
xfeed_6788 1 0 decap_w0
xfeed_6787 1 0 decap_w0
xfeed_6786 1 0 decap_w0
xfeed_6785 1 0 decap_w0
xfeed_6784 1 0 decap_w0
xfeed_6783 1 0 decap_w0
xfeed_6782 1 0 decap_w0
xfeed_6781 1 0 decap_w0
xfeed_6780 1 0 decap_w0
xfeed_2479 1 0 decap_w0
xfeed_2478 1 0 decap_w0
xfeed_2477 1 0 decap_w0
xfeed_2476 1 0 decap_w0
xfeed_2475 1 0 decap_w0
xfeed_2474 1 0 decap_w0
xfeed_2473 1 0 decap_w0
xfeed_2472 1 0 decap_w0
xfeed_2471 1 0 decap_w0
xfeed_2470 1 0 decap_w0
xfeed_459 1 0 decap_w0
xfeed_458 1 0 decap_w0
xfeed_457 1 0 decap_w0
xfeed_456 1 0 decap_w0
xfeed_455 1 0 decap_w0
xfeed_454 1 0 decap_w0
xfeed_453 1 0 decap_w0
xfeed_452 1 0 decap_w0
xfeed_451 1 0 decap_w0
xfeed_450 1 0 decap_w0
xfeed_1940 1 0 decap_w0
xfeed_1941 1 0 decap_w0
xfeed_1942 1 0 decap_w0
xfeed_1943 1 0 decap_w0
xfeed_1944 1 0 decap_w0
xfeed_1945 1 0 decap_w0
xfeed_1946 1 0 decap_w0
xfeed_1947 1 0 decap_w0
xfeed_1948 1 0 decap_w0
xfeed_1949 1 0 decap_w0
xfeed_28759 1 0 decap_w0
xfeed_18449 1 0 decap_w0
xfeed_18448 1 0 decap_w0
xfeed_18447 1 0 decap_w0
xfeed_18446 1 0 decap_w0
xfeed_18445 1 0 decap_w0
xfeed_18444 1 0 decap_w0
xfeed_18443 1 0 decap_w0
xfeed_18442 1 0 decap_w0
xfeed_18441 1 0 decap_w0
xfeed_18440 1 0 decap_w0
xfeed_17919 1 0 decap_w0
xfeed_17918 1 0 decap_w0
xfeed_17917 1 0 decap_w0
xfeed_17916 1 0 decap_w0
xfeed_17915 1 0 decap_w0
xfeed_17914 1 0 decap_w0
xfeed_17913 1 0 decap_w0
xfeed_17912 1 0 decap_w0
xfeed_17911 1 0 decap_w0
xfeed_17910 1 0 decap_w0
xfeed_14139 1 0 decap_w0
xfeed_14138 1 0 decap_w0
xfeed_14137 1 0 decap_w0
xfeed_14136 1 0 decap_w0
xfeed_14135 1 0 decap_w0
xfeed_14134 1 0 decap_w0
xfeed_14133 1 0 decap_w0
xfeed_14132 1 0 decap_w0
xfeed_13609 1 0 decap_w0
xfeed_13608 1 0 decap_w0
xfeed_13607 1 0 decap_w0
xfeed_13606 1 0 decap_w0
xfeed_13605 1 0 decap_w0
xfeed_13604 1 0 decap_w0
xfeed_13603 1 0 decap_w0
xfeed_13602 1 0 decap_w0
xfeed_13601 1 0 tie
xfeed_13600 1 0 decap_w0
xfeed_12999 1 0 decap_w0
xfeed_12998 1 0 decap_w0
xfeed_12997 1 0 decap_w0
xfeed_12996 1 0 decap_w0
xfeed_12995 1 0 decap_w0
xfeed_12994 1 0 decap_w0
xfeed_12993 1 0 decap_w0
xfeed_12992 1 0 decap_w0
xfeed_12991 1 0 decap_w0
xfeed_12990 1 0 decap_w0
xfeed_7409 1 0 decap_w0
xfeed_7408 1 0 decap_w0
xfeed_7407 1 0 decap_w0
xfeed_7406 1 0 decap_w0
xfeed_7405 1 0 decap_w0
xfeed_7404 1 0 decap_w0
xfeed_7403 1 0 decap_w0
xfeed_7402 1 0 decap_w0
xfeed_7401 1 0 decap_w0
xfeed_7400 1 0 decap_w0
xfeed_30459 1 0 decap_w0
xfeed_30458 1 0 decap_w0
xfeed_30457 1 0 decap_w0
xfeed_30456 1 0 decap_w0
xfeed_30455 1 0 decap_w0
xfeed_30454 1 0 decap_w0
xfeed_30453 1 0 decap_w0
xfeed_30452 1 0 decap_w0
xfeed_30451 1 0 decap_w0
xfeed_30450 1 0 decap_w0
xfeed_29299 1 0 decap_w0
xfeed_29298 1 0 decap_w0
xfeed_29297 1 0 decap_w0
xfeed_29296 1 0 decap_w0
xfeed_29295 1 0 decap_w0
xfeed_29294 1 0 decap_w0
xfeed_29293 1 0 decap_w0
xfeed_29292 1 0 decap_w0
xfeed_29291 1 0 decap_w0
xfeed_29290 1 0 decap_w0
xfeed_28765 1 0 decap_w0
xfeed_28764 1 0 decap_w0
xfeed_28763 1 0 decap_w0
xfeed_28762 1 0 decap_w0
xfeed_28761 1 0 decap_w0
xfeed_28760 1 0 decap_w0
xfeed_24459 1 0 decap_w0
xfeed_24458 1 0 decap_w0
xfeed_24457 1 0 decap_w0
xfeed_24456 1 0 decap_w0
xfeed_24455 1 0 decap_w0
xfeed_24454 1 0 decap_w0
xfeed_24453 1 0 decap_w0
xfeed_24452 1 0 decap_w0
xfeed_24451 1 0 decap_w0
xfeed_24450 1 0 decap_w0
xfeed_23926 1 0 decap_w0
xfeed_23925 1 0 decap_w0
xfeed_23924 1 0 decap_w0
xfeed_23923 1 0 decap_w0
xfeed_23922 1 0 decap_w0
xfeed_23921 1 0 decap_w0
xfeed_23920 1 0 decap_w0
xfeed_20149 1 0 decap_w0
xfeed_20148 1 0 decap_w0
xfeed_20147 1 0 decap_w0
xfeed_20146 1 0 decap_w0
xfeed_20145 1 0 decap_w0
xfeed_20144 1 0 decap_w0
xfeed_20143 1 0 decap_w0
xfeed_20142 1 0 decap_w0
xfeed_20141 1 0 decap_w0
xfeed_20140 1 0 decap_w0
xfeed_6799 1 0 decap_w0
xfeed_6798 1 0 decap_w0
xfeed_6797 1 0 decap_w0
xfeed_6796 1 0 decap_w0
xfeed_6795 1 0 decap_w0
xfeed_6794 1 0 decap_w0
xfeed_6793 1 0 decap_w0
xfeed_6792 1 0 decap_w0
xfeed_6791 1 0 decap_w0
xfeed_6790 1 0 decap_w0
xfeed_2489 1 0 decap_w0
xfeed_2488 1 0 decap_w0
xfeed_2487 1 0 decap_w0
xfeed_2486 1 0 decap_w0
xfeed_2485 1 0 decap_w0
xfeed_2484 1 0 decap_w0
xfeed_2483 1 0 decap_w0
xfeed_2482 1 0 decap_w0
xfeed_2481 1 0 decap_w0
xfeed_2480 1 0 decap_w0
xfeed_469 1 0 decap_w0
xfeed_468 1 0 decap_w0
xfeed_467 1 0 decap_w0
xfeed_466 1 0 decap_w0
xfeed_465 1 0 decap_w0
xfeed_464 1 0 decap_w0
xfeed_463 1 0 decap_w0
xfeed_462 1 0 decap_w0
xfeed_461 1 0 decap_w0
xfeed_460 1 0 decap_w0
xfeed_1950 1 0 decap_w0
xfeed_1951 1 0 decap_w0
xfeed_1952 1 0 decap_w0
xfeed_1953 1 0 decap_w0
xfeed_1954 1 0 decap_w0
xfeed_1955 1 0 decap_w0
xfeed_1956 1 0 decap_w0
xfeed_1957 1 0 decap_w0
xfeed_1958 1 0 decap_w0
xfeed_1959 1 0 decap_w0
xfeed_28769 1 0 decap_w0
xfeed_28768 1 0 decap_w0
xfeed_28767 1 0 decap_w0
xfeed_28766 1 0 decap_w0
xfeed_23929 1 0 decap_w0
xfeed_23928 1 0 decap_w0
xfeed_23927 1 0 decap_w0
xfeed_18459 1 0 decap_w0
xfeed_18458 1 0 decap_w0
xfeed_18457 1 0 decap_w0
xfeed_18456 1 0 decap_w0
xfeed_18455 1 0 decap_w0
xfeed_18454 1 0 decap_w0
xfeed_18453 1 0 decap_w0
xfeed_18452 1 0 decap_w0
xfeed_18451 1 0 decap_w0
xfeed_18450 1 0 decap_w0
xfeed_17929 1 0 decap_w0
xfeed_17928 1 0 decap_w0
xfeed_17927 1 0 decap_w0
xfeed_17926 1 0 decap_w0
xfeed_17925 1 0 decap_w0
xfeed_17924 1 0 decap_w0
xfeed_17923 1 0 decap_w0
xfeed_17922 1 0 decap_w0
xfeed_17921 1 0 decap_w0
xfeed_17920 1 0 decap_w0
xfeed_14149 1 0 decap_w0
xfeed_14148 1 0 decap_w0
xfeed_14147 1 0 decap_w0
xfeed_14146 1 0 decap_w0
xfeed_14145 1 0 decap_w0
xfeed_14144 1 0 decap_w0
xfeed_14143 1 0 decap_w0
xfeed_14142 1 0 decap_w0
xfeed_14141 1 0 decap_w0
xfeed_14140 1 0 decap_w0
xfeed_13619 1 0 decap_w0
xfeed_13618 1 0 decap_w0
xfeed_13617 1 0 decap_w0
xfeed_13616 1 0 decap_w0
xfeed_13615 1 0 decap_w0
xfeed_13614 1 0 decap_w0
xfeed_13613 1 0 decap_w0
xfeed_13612 1 0 decap_w0
xfeed_13611 1 0 decap_w0
xfeed_13610 1 0 decap_w0
xfeed_7416 1 0 decap_w0
xfeed_7415 1 0 decap_w0
xfeed_7414 1 0 decap_w0
xfeed_7413 1 0 decap_w0
xfeed_7412 1 0 decap_w0
xfeed_7411 1 0 tie
xfeed_7410 1 0 decap_w0
xfeed_3109 1 0 decap_w0
xfeed_3108 1 0 decap_w0
xfeed_3107 1 0 decap_w0
xfeed_3106 1 0 decap_w0
xfeed_3105 1 0 decap_w0
xfeed_3104 1 0 decap_w0
xfeed_3103 1 0 decap_w0
xfeed_3102 1 0 decap_w0
xfeed_3101 1 0 decap_w0
xfeed_3100 1 0 decap_w0
xfeed_30469 1 0 decap_w0
xfeed_30468 1 0 decap_w0
xfeed_30467 1 0 decap_w0
xfeed_30466 1 0 decap_w0
xfeed_30465 1 0 decap_w0
xfeed_30464 1 0 decap_w0
xfeed_30463 1 0 decap_w0
xfeed_30462 1 0 decap_w0
xfeed_30461 1 0 decap_w0
xfeed_30460 1 0 decap_w0
xfeed_28772 1 0 decap_w0
xfeed_28771 1 0 decap_w0
xfeed_28770 1 0 decap_w0
xfeed_24469 1 0 decap_w0
xfeed_24468 1 0 decap_w0
xfeed_24467 1 0 decap_w0
xfeed_24466 1 0 decap_w0
xfeed_24465 1 0 decap_w0
xfeed_24464 1 0 decap_w0
xfeed_24463 1 0 decap_w0
xfeed_24462 1 0 decap_w0
xfeed_24461 1 0 decap_w0
xfeed_24460 1 0 decap_w0
xfeed_23933 1 0 decap_w0
xfeed_23932 1 0 decap_w0
xfeed_23931 1 0 decap_w0
xfeed_23930 1 0 decap_w0
xfeed_20159 1 0 decap_w0
xfeed_20158 1 0 decap_w0
xfeed_20157 1 0 decap_w0
xfeed_20156 1 0 decap_w0
xfeed_20155 1 0 decap_w0
xfeed_20154 1 0 decap_w0
xfeed_20153 1 0 decap_w0
xfeed_20152 1 0 decap_w0
xfeed_20151 1 0 decap_w0
xfeed_20150 1 0 decap_w0
xfeed_7419 1 0 decap_w0
xfeed_7418 1 0 decap_w0
xfeed_7417 1 0 decap_w0
xfeed_2499 1 0 decap_w0
xfeed_2498 1 0 decap_w0
xfeed_2497 1 0 decap_w0
xfeed_2496 1 0 decap_w0
xfeed_2495 1 0 decap_w0
xfeed_2494 1 0 decap_w0
xfeed_2493 1 0 decap_w0
xfeed_2492 1 0 decap_w0
xfeed_2491 1 0 decap_w0
xfeed_2490 1 0 decap_w0
xfeed_479 1 0 decap_w0
xfeed_478 1 0 decap_w0
xfeed_477 1 0 decap_w0
xfeed_476 1 0 decap_w0
xfeed_475 1 0 decap_w0
xfeed_474 1 0 decap_w0
xfeed_473 1 0 decap_w0
xfeed_472 1 0 decap_w0
xfeed_471 1 0 decap_w0
xfeed_470 1 0 decap_w0
xfeed_1960 1 0 decap_w0
xfeed_1961 1 0 decap_w0
xfeed_1962 1 0 decap_w0
xfeed_1963 1 0 decap_w0
xfeed_1964 1 0 decap_w0
xfeed_1965 1 0 decap_w0
xfeed_1966 1 0 decap_w0
xfeed_1967 1 0 decap_w0
xfeed_1968 1 0 decap_w0
xfeed_1969 1 0 decap_w0
xfeed_28779 1 0 decap_w0
xfeed_28778 1 0 decap_w0
xfeed_28777 1 0 decap_w0
xfeed_28776 1 0 decap_w0
xfeed_28775 1 0 decap_w0
xfeed_28774 1 0 decap_w0
xfeed_28773 1 0 decap_w0
xfeed_23939 1 0 decap_w0
xfeed_23938 1 0 decap_w0
xfeed_23937 1 0 decap_w0
xfeed_23936 1 0 decap_w0
xfeed_23935 1 0 decap_w0
xfeed_23934 1 0 decap_w0
xfeed_18469 1 0 decap_w0
xfeed_18468 1 0 decap_w0
xfeed_18467 1 0 decap_w0
xfeed_18466 1 0 decap_w0
xfeed_18465 1 0 decap_w0
xfeed_18464 1 0 decap_w0
xfeed_18463 1 0 decap_w0
xfeed_18462 1 0 decap_w0
xfeed_18461 1 0 decap_w0
xfeed_18460 1 0 decap_w0
xfeed_17939 1 0 decap_w0
xfeed_17938 1 0 decap_w0
xfeed_17937 1 0 decap_w0
xfeed_17936 1 0 decap_w0
xfeed_17935 1 0 decap_w0
xfeed_17934 1 0 decap_w0
xfeed_17933 1 0 decap_w0
xfeed_17932 1 0 decap_w0
xfeed_17931 1 0 decap_w0
xfeed_17930 1 0 decap_w0
xfeed_14159 1 0 decap_w0
xfeed_14158 1 0 decap_w0
xfeed_14157 1 0 decap_w0
xfeed_14156 1 0 decap_w0
xfeed_14155 1 0 decap_w0
xfeed_14154 1 0 decap_w0
xfeed_14153 1 0 decap_w0
xfeed_14152 1 0 decap_w0
xfeed_14151 1 0 decap_w0
xfeed_14150 1 0 decap_w0
xfeed_13629 1 0 decap_w0
xfeed_13628 1 0 decap_w0
xfeed_13627 1 0 decap_w0
xfeed_13626 1 0 decap_w0
xfeed_13625 1 0 decap_w0
xfeed_13624 1 0 decap_w0
xfeed_13623 1 0 decap_w0
xfeed_13622 1 0 decap_w0
xfeed_13621 1 0 decap_w0
xfeed_13620 1 0 decap_w0
xfeed_7423 1 0 decap_w0
xfeed_7422 1 0 decap_w0
xfeed_7421 1 0 decap_w0
xfeed_7420 1 0 decap_w0
xfeed_3119 1 0 decap_w0
xfeed_3118 1 0 decap_w0
xfeed_3117 1 0 decap_w0
xfeed_3116 1 0 decap_w0
xfeed_3115 1 0 decap_w0
xfeed_3114 1 0 decap_w0
xfeed_3113 1 0 decap_w0
xfeed_3112 1 0 decap_w0
xfeed_3111 1 0 decap_w0
xfeed_3110 1 0 decap_w0
xfeed_30479 1 0 decap_w0
xfeed_30478 1 0 decap_w0
xfeed_30477 1 0 decap_w0
xfeed_30476 1 0 decap_w0
xfeed_30475 1 0 decap_w0
xfeed_30474 1 0 decap_w0
xfeed_30473 1 0 decap_w0
xfeed_30472 1 0 decap_w0
xfeed_30471 1 0 decap_w0
xfeed_30470 1 0 decap_w0
xfeed_24479 1 0 decap_w0
xfeed_24478 1 0 decap_w0
xfeed_24477 1 0 decap_w0
xfeed_24476 1 0 decap_w0
xfeed_24475 1 0 decap_w0
xfeed_24474 1 0 decap_w0
xfeed_24473 1 0 decap_w0
xfeed_24472 1 0 decap_w0
xfeed_24471 1 0 decap_w0
xfeed_24470 1 0 decap_w0
xfeed_23940 1 0 decap_w0
xfeed_20169 1 0 decap_w0
xfeed_20168 1 0 decap_w0
xfeed_20167 1 0 decap_w0
xfeed_20166 1 0 decap_w0
xfeed_20165 1 0 decap_w0
xfeed_20164 1 0 tie
xfeed_20163 1 0 decap_w0
xfeed_20162 1 0 decap_w0
xfeed_20161 1 0 decap_w0
xfeed_20160 1 0 decap_w0
xfeed_7429 1 0 decap_w0
xfeed_7428 1 0 decap_w0
xfeed_7427 1 0 decap_w0
xfeed_7426 1 0 decap_w0
xfeed_7425 1 0 decap_w0
xfeed_7424 1 0 decap_w0
xfeed_489 1 0 decap_w0
xfeed_488 1 0 decap_w0
xfeed_487 1 0 decap_w0
xfeed_486 1 0 decap_w0
xfeed_485 1 0 decap_w0
xfeed_484 1 0 decap_w0
xfeed_483 1 0 decap_w0
xfeed_482 1 0 decap_w0
xfeed_481 1 0 decap_w0
xfeed_480 1 0 decap_w0
xfeed_1970 1 0 decap_w0
xfeed_1971 1 0 decap_w0
xfeed_1972 1 0 decap_w0
xfeed_1973 1 0 decap_w0
xfeed_1974 1 0 decap_w0
xfeed_1975 1 0 decap_w0
xfeed_1976 1 0 decap_w0
xfeed_1977 1 0 decap_w0
xfeed_1978 1 0 decap_w0
xfeed_1979 1 0 decap_w0
xfeed_28789 1 0 decap_w0
xfeed_28788 1 0 decap_w0
xfeed_28787 1 0 decap_w0
xfeed_28786 1 0 decap_w0
xfeed_28785 1 0 decap_w0
xfeed_28784 1 0 decap_w0
xfeed_28783 1 0 decap_w0
xfeed_28782 1 0 decap_w0
xfeed_28781 1 0 decap_w0
xfeed_28780 1 0 decap_w0
xfeed_23949 1 0 decap_w0
xfeed_23948 1 0 decap_w0
xfeed_23947 1 0 decap_w0
xfeed_23946 1 0 decap_w0
xfeed_23945 1 0 decap_w0
xfeed_23944 1 0 decap_w0
xfeed_23943 1 0 decap_w0
xfeed_23942 1 0 decap_w0
xfeed_23941 1 0 decap_w0
xfeed_18479 1 0 decap_w0
xfeed_18478 1 0 decap_w0
xfeed_18477 1 0 decap_w0
xfeed_18476 1 0 decap_w0
xfeed_18475 1 0 decap_w0
xfeed_18474 1 0 decap_w0
xfeed_18473 1 0 decap_w0
xfeed_18472 1 0 decap_w0
xfeed_18471 1 0 decap_w0
xfeed_18470 1 0 decap_w0
xfeed_17949 1 0 decap_w0
xfeed_17948 1 0 decap_w0
xfeed_17947 1 0 decap_w0
xfeed_17946 1 0 decap_w0
xfeed_17945 1 0 decap_w0
xfeed_17944 1 0 decap_w0
xfeed_17943 1 0 decap_w0
xfeed_17942 1 0 decap_w0
xfeed_17941 1 0 decap_w0
xfeed_17940 1 0 decap_w0
xfeed_14169 1 0 decap_w0
xfeed_14168 1 0 decap_w0
xfeed_14167 1 0 decap_w0
xfeed_14166 1 0 decap_w0
xfeed_14165 1 0 decap_w0
xfeed_14164 1 0 decap_w0
xfeed_14163 1 0 decap_w0
xfeed_14162 1 0 decap_w0
xfeed_14161 1 0 decap_w0
xfeed_14160 1 0 decap_w0
xfeed_13639 1 0 decap_w0
xfeed_13638 1 0 decap_w0
xfeed_13637 1 0 decap_w0
xfeed_13636 1 0 decap_w0
xfeed_13635 1 0 decap_w0
xfeed_13634 1 0 decap_w0
xfeed_13633 1 0 decap_w0
xfeed_13632 1 0 decap_w0
xfeed_13631 1 0 decap_w0
xfeed_13630 1 0 decap_w0
xfeed_7430 1 0 decap_w0
xfeed_3129 1 0 decap_w0
xfeed_3128 1 0 decap_w0
xfeed_3127 1 0 decap_w0
xfeed_3126 1 0 decap_w0
xfeed_3125 1 0 decap_w0
xfeed_3124 1 0 decap_w0
xfeed_3123 1 0 decap_w0
xfeed_3122 1 0 decap_w0
xfeed_3121 1 0 decap_w0
xfeed_3120 1 0 decap_w0
xfeed_30489 1 0 decap_w0
xfeed_30488 1 0 decap_w0
xfeed_30487 1 0 decap_w0
xfeed_30486 1 0 decap_w0
xfeed_30485 1 0 decap_w0
xfeed_30484 1 0 decap_w0
xfeed_30483 1 0 decap_w0
xfeed_30482 1 0 decap_w0
xfeed_30481 1 0 decap_w0
xfeed_30480 1 0 decap_w0
xfeed_29409 1 0 decap_w0
xfeed_29408 1 0 decap_w0
xfeed_29407 1 0 decap_w0
xfeed_29406 1 0 decap_w0
xfeed_29405 1 0 decap_w0
xfeed_29404 1 0 decap_w0
xfeed_29403 1 0 decap_w0
xfeed_29402 1 0 decap_w0
xfeed_29401 1 0 decap_w0
xfeed_29400 1 0 decap_w0
xfeed_24486 1 0 decap_w0
xfeed_24485 1 0 decap_w0
xfeed_24484 1 0 decap_w0
xfeed_24483 1 0 decap_w0
xfeed_24482 1 0 decap_w0
xfeed_24481 1 0 decap_w0
xfeed_24480 1 0 decap_w0
xfeed_20179 1 0 decap_w0
xfeed_20178 1 0 decap_w0
xfeed_20177 1 0 decap_w0
xfeed_20176 1 0 decap_w0
xfeed_20175 1 0 decap_w0
xfeed_20174 1 0 decap_w0
xfeed_20173 1 0 decap_w0
xfeed_20172 1 0 decap_w0
xfeed_20171 1 0 decap_w0
xfeed_20170 1 0 decap_w0
xfeed_7439 1 0 decap_w0
xfeed_7438 1 0 decap_w0
xfeed_7437 1 0 decap_w0
xfeed_7436 1 0 decap_w0
xfeed_7435 1 0 decap_w0
xfeed_7434 1 0 decap_w0
xfeed_7433 1 0 decap_w0
xfeed_7432 1 0 decap_w0
xfeed_7431 1 0 decap_w0
xfeed_6909 1 0 decap_w0
xfeed_6908 1 0 decap_w0
xfeed_6907 1 0 decap_w0
xfeed_6906 1 0 decap_w0
xfeed_6905 1 0 decap_w0
xfeed_6904 1 0 decap_w0
xfeed_6903 1 0 decap_w0
xfeed_6902 1 0 decap_w0
xfeed_6901 1 0 decap_w0
xfeed_6900 1 0 decap_w0
xfeed_499 1 0 decap_w0
xfeed_498 1 0 decap_w0
xfeed_497 1 0 decap_w0
xfeed_496 1 0 decap_w0
xfeed_495 1 0 decap_w0
xfeed_494 1 0 decap_w0
xfeed_493 1 0 decap_w0
xfeed_492 1 0 decap_w0
xfeed_491 1 0 decap_w0
xfeed_490 1 0 decap_w0
xsubckt_6_inv_x0 1 0 135 16 inv_x0
xfeed_1980 1 0 decap_w0
xfeed_1981 1 0 decap_w0
xfeed_1982 1 0 decap_w0
xfeed_1983 1 0 decap_w0
xfeed_1984 1 0 decap_w0
xfeed_1985 1 0 decap_w0
xfeed_1986 1 0 decap_w0
xfeed_1987 1 0 decap_w0
xfeed_1988 1 0 decap_w0
xfeed_1989 1 0 decap_w0
xfeed_28799 1 0 decap_w0
xfeed_28798 1 0 decap_w0
xfeed_28797 1 0 decap_w0
xfeed_28796 1 0 decap_w0
xfeed_28795 1 0 decap_w0
xfeed_28794 1 0 decap_w0
xfeed_28793 1 0 decap_w0
xfeed_28792 1 0 decap_w0
xfeed_28791 1 0 decap_w0
xfeed_28790 1 0 decap_w0
xfeed_24489 1 0 decap_w0
xfeed_24488 1 0 decap_w0
xfeed_24487 1 0 decap_w0
xfeed_23959 1 0 decap_w0
xfeed_23958 1 0 decap_w0
xfeed_23957 1 0 decap_w0
xfeed_23956 1 0 decap_w0
xfeed_23955 1 0 decap_w0
xfeed_23954 1 0 decap_w0
xfeed_23953 1 0 decap_w0
xfeed_23952 1 0 tie
xfeed_23951 1 0 decap_w0
xfeed_23950 1 0 decap_w0
xfeed_18489 1 0 decap_w0
xfeed_18488 1 0 decap_w0
xfeed_18487 1 0 decap_w0
xfeed_18486 1 0 decap_w0
xfeed_18485 1 0 decap_w0
xfeed_18484 1 0 decap_w0
xfeed_18483 1 0 decap_w0
xfeed_18482 1 0 decap_w0
xfeed_18481 1 0 decap_w0
xfeed_18480 1 0 decap_w0
xfeed_17959 1 0 decap_w0
xfeed_17958 1 0 decap_w0
xfeed_17957 1 0 decap_w0
xfeed_17956 1 0 decap_w0
xfeed_17955 1 0 decap_w0
xfeed_17954 1 0 decap_w0
xfeed_17953 1 0 decap_w0
xfeed_17952 1 0 decap_w0
xfeed_17951 1 0 decap_w0
xfeed_17950 1 0 decap_w0
xfeed_14179 1 0 decap_w0
xfeed_14178 1 0 decap_w0
xfeed_14177 1 0 decap_w0
xfeed_14176 1 0 decap_w0
xfeed_14175 1 0 decap_w0
xfeed_14174 1 0 decap_w0
xfeed_14173 1 0 decap_w0
xfeed_14172 1 0 decap_w0
xfeed_14171 1 0 decap_w0
xfeed_14170 1 0 decap_w0
xfeed_13649 1 0 decap_w0
xfeed_13648 1 0 decap_w0
xfeed_13647 1 0 decap_w0
xfeed_13646 1 0 decap_w0
xfeed_13645 1 0 decap_w0
xfeed_13644 1 0 decap_w0
xfeed_13643 1 0 decap_w0
xfeed_13642 1 0 decap_w0
xfeed_13641 1 0 decap_w0
xfeed_13640 1 0 decap_w0
xfeed_3137 1 0 decap_w0
xfeed_3136 1 0 decap_w0
xfeed_3135 1 0 decap_w0
xfeed_3134 1 0 decap_w0
xfeed_3133 1 0 decap_w0
xfeed_3132 1 0 decap_w0
xfeed_3131 1 0 decap_w0
xfeed_3130 1 0 decap_w0
xfeed_31109 1 0 decap_w0
xfeed_31108 1 0 decap_w0
xfeed_31107 1 0 decap_w0
xfeed_31106 1 0 decap_w0
xfeed_31105 1 0 decap_w0
xfeed_31104 1 0 decap_w0
xfeed_31103 1 0 decap_w0
xfeed_31102 1 0 decap_w0
xfeed_31101 1 0 decap_w0
xfeed_31100 1 0 decap_w0
xfeed_30499 1 0 decap_w0
xfeed_30498 1 0 decap_w0
xfeed_30497 1 0 decap_w0
xfeed_30496 1 0 decap_w0
xfeed_30495 1 0 decap_w0
xfeed_30494 1 0 decap_w0
xfeed_30493 1 0 decap_w0
xfeed_30492 1 0 decap_w0
xfeed_30491 1 0 decap_w0
xfeed_30490 1 0 decap_w0
xfeed_29419 1 0 decap_w0
xfeed_29418 1 0 decap_w0
xfeed_29417 1 0 decap_w0
xfeed_29416 1 0 decap_w0
xfeed_29415 1 0 decap_w0
xfeed_29414 1 0 decap_w0
xfeed_29413 1 0 decap_w0
xfeed_29412 1 0 decap_w0
xfeed_29411 1 0 decap_w0
xfeed_29410 1 0 decap_w0
xfeed_25109 1 0 decap_w0
xfeed_25108 1 0 decap_w0
xfeed_25107 1 0 decap_w0
xfeed_25106 1 0 decap_w0
xfeed_25105 1 0 decap_w0
xfeed_25104 1 0 decap_w0
xfeed_25103 1 0 decap_w0
xfeed_25102 1 0 decap_w0
xfeed_25101 1 0 decap_w0
xfeed_25100 1 0 decap_w0
xfeed_24493 1 0 decap_w0
xfeed_24492 1 0 decap_w0
xfeed_24491 1 0 decap_w0
xfeed_24490 1 0 decap_w0
xfeed_20189 1 0 decap_w0
xfeed_20188 1 0 decap_w0
xfeed_20187 1 0 decap_w0
xfeed_20186 1 0 decap_w0
xfeed_20185 1 0 decap_w0
xfeed_20184 1 0 decap_w0
xfeed_20183 1 0 decap_w0
xfeed_20182 1 0 decap_w0
xfeed_20181 1 0 decap_w0
xfeed_20180 1 0 decap_w0
xfeed_19103 1 0 decap_w0
xfeed_19102 1 0 decap_w0
xfeed_19101 1 0 decap_w0
xfeed_19100 1 0 decap_w0
xfeed_7449 1 0 decap_w0
xfeed_7448 1 0 decap_w0
xfeed_7447 1 0 decap_w0
xfeed_7446 1 0 decap_w0
xfeed_7445 1 0 decap_w0
xfeed_7444 1 0 decap_w0
xfeed_7443 1 0 decap_w0
xfeed_7442 1 0 decap_w0
xfeed_7441 1 0 decap_w0
xfeed_7440 1 0 decap_w0
xfeed_6919 1 0 decap_w0
xfeed_6918 1 0 decap_w0
xfeed_6917 1 0 decap_w0
xfeed_6916 1 0 decap_w0
xfeed_6915 1 0 decap_w0
xfeed_6914 1 0 decap_w0
xfeed_6913 1 0 decap_w0
xfeed_6912 1 0 decap_w0
xfeed_6911 1 0 decap_w0
xfeed_6910 1 0 decap_w0
xfeed_3139 1 0 decap_w0
xfeed_3138 1 0 decap_w0
xfeed_2609 1 0 decap_w0
xfeed_2608 1 0 decap_w0
xfeed_2607 1 0 decap_w0
xfeed_2606 1 0 decap_w0
xfeed_2605 1 0 decap_w0
xfeed_2604 1 0 decap_w0
xfeed_2603 1 0 decap_w0
xfeed_2602 1 0 decap_w0
xfeed_2601 1 0 decap_w0
xfeed_2600 1 0 decap_w0
xfeed_1990 1 0 decap_w0
xfeed_1991 1 0 decap_w0
xfeed_1992 1 0 decap_w0
xfeed_1993 1 0 decap_w0
xfeed_1994 1 0 decap_w0
xfeed_1995 1 0 decap_w0
xfeed_1996 1 0 decap_w0
xfeed_1997 1 0 decap_w0
xfeed_1998 1 0 decap_w0
xfeed_1999 1 0 decap_w0
xfeed_24499 1 0 decap_w0
xfeed_24498 1 0 decap_w0
xfeed_24497 1 0 decap_w0
xfeed_24496 1 0 decap_w0
xfeed_24495 1 0 decap_w0
xfeed_24494 1 0 decap_w0
xfeed_23969 1 0 decap_w0
xfeed_23968 1 0 decap_w0
xfeed_23967 1 0 decap_w0
xfeed_23966 1 0 decap_w0
xfeed_23965 1 0 decap_w0
xfeed_23964 1 0 decap_w0
xfeed_23963 1 0 decap_w0
xfeed_23962 1 0 decap_w0
xfeed_23961 1 0 decap_w0
xfeed_23960 1 0 decap_w0
xfeed_19109 1 0 decap_w0
xfeed_19108 1 0 decap_w0
xfeed_19107 1 0 decap_w0
xfeed_19106 1 0 decap_w0
xfeed_19105 1 0 decap_w0
xfeed_19104 1 0 decap_w0
xfeed_18499 1 0 decap_w0
xfeed_18498 1 0 decap_w0
xfeed_18497 1 0 decap_w0
xfeed_18496 1 0 decap_w0
xfeed_18495 1 0 decap_w0
xfeed_18494 1 0 decap_w0
xfeed_18493 1 0 decap_w0
xfeed_18492 1 0 decap_w0
xfeed_18491 1 0 decap_w0
xfeed_18490 1 0 decap_w0
xfeed_17969 1 0 decap_w0
xfeed_17968 1 0 decap_w0
xfeed_17967 1 0 decap_w0
xfeed_17966 1 0 decap_w0
xfeed_17965 1 0 decap_w0
xfeed_17964 1 0 decap_w0
xfeed_17963 1 0 decap_w0
xfeed_17962 1 0 decap_w0
xfeed_17961 1 0 decap_w0
xfeed_17960 1 0 decap_w0
xfeed_14189 1 0 decap_w0
xfeed_14188 1 0 decap_w0
xfeed_14187 1 0 decap_w0
xfeed_14186 1 0 decap_w0
xfeed_14185 1 0 decap_w0
xfeed_14184 1 0 decap_w0
xfeed_14183 1 0 decap_w0
xfeed_14182 1 0 decap_w0
xfeed_14181 1 0 decap_w0
xfeed_14180 1 0 decap_w0
xfeed_13659 1 0 decap_w0
xfeed_13658 1 0 decap_w0
xfeed_13657 1 0 decap_w0
xfeed_13656 1 0 decap_w0
xfeed_13655 1 0 decap_w0
xfeed_13654 1 0 decap_w0
xfeed_13653 1 0 decap_w0
xfeed_13652 1 0 decap_w0
xfeed_13651 1 0 decap_w0
xfeed_13650 1 0 decap_w0
xfeed_3144 1 0 decap_w0
xfeed_3143 1 0 decap_w0
xfeed_3142 1 0 decap_w0
xfeed_3141 1 0 decap_w0
xfeed_3140 1 0 decap_w0
xfeed_31119 1 0 decap_w0
xfeed_31118 1 0 decap_w0
xfeed_31117 1 0 decap_w0
xfeed_31116 1 0 decap_w0
xfeed_31115 1 0 decap_w0
xfeed_31114 1 0 decap_w0
xfeed_31113 1 0 decap_w0
xfeed_31112 1 0 decap_w0
xfeed_31111 1 0 decap_w0
xfeed_31110 1 0 decap_w0
xfeed_29429 1 0 decap_w0
xfeed_29428 1 0 decap_w0
xfeed_29427 1 0 decap_w0
xfeed_29426 1 0 decap_w0
xfeed_29425 1 0 decap_w0
xfeed_29424 1 0 decap_w0
xfeed_29423 1 0 decap_w0
xfeed_29422 1 0 decap_w0
xfeed_29421 1 0 decap_w0
xfeed_29420 1 0 decap_w0
xfeed_25119 1 0 decap_w0
xfeed_25118 1 0 decap_w0
xfeed_25117 1 0 decap_w0
xfeed_25116 1 0 decap_w0
xfeed_25115 1 0 decap_w0
xfeed_25114 1 0 decap_w0
xfeed_25113 1 0 decap_w0
xfeed_25112 1 0 decap_w0
xfeed_25111 1 0 decap_w0
xfeed_25110 1 0 decap_w0
xfeed_20199 1 0 decap_w0
xfeed_20198 1 0 decap_w0
xfeed_20197 1 0 decap_w0
xfeed_20196 1 0 decap_w0
xfeed_20195 1 0 decap_w0
xfeed_20194 1 0 decap_w0
xfeed_20193 1 0 decap_w0
xfeed_20192 1 0 decap_w0
xfeed_20191 1 0 decap_w0
xfeed_20190 1 0 decap_w0
xfeed_19110 1 0 decap_w0
xfeed_7459 1 0 decap_w0
xfeed_7458 1 0 decap_w0
xfeed_7457 1 0 decap_w0
xfeed_7456 1 0 decap_w0
xfeed_7455 1 0 decap_w0
xfeed_7454 1 0 decap_w0
xfeed_7453 1 0 decap_w0
xfeed_7452 1 0 decap_w0
xfeed_7451 1 0 decap_w0
xfeed_7450 1 0 decap_w0
xfeed_6929 1 0 decap_w0
xfeed_6928 1 0 decap_w0
xfeed_6927 1 0 decap_w0
xfeed_6926 1 0 decap_w0
xfeed_6925 1 0 decap_w0
xfeed_6924 1 0 decap_w0
xfeed_6923 1 0 decap_w0
xfeed_6922 1 0 decap_w0
xfeed_6921 1 0 decap_w0
xfeed_6920 1 0 decap_w0
xfeed_3149 1 0 decap_w0
xfeed_3148 1 0 decap_w0
xfeed_3147 1 0 decap_w0
xfeed_3146 1 0 decap_w0
xfeed_3145 1 0 decap_w0
xfeed_2619 1 0 decap_w0
xfeed_2618 1 0 decap_w0
xfeed_2617 1 0 decap_w0
xfeed_2616 1 0 decap_w0
xfeed_2615 1 0 decap_w0
xfeed_2614 1 0 decap_w0
xfeed_2613 1 0 decap_w0
xfeed_2612 1 0 decap_w0
xfeed_2611 1 0 decap_w0
xfeed_2610 1 0 decap_w0
xfeed_23979 1 0 decap_w0
xfeed_23978 1 0 decap_w0
xfeed_23977 1 0 decap_w0
xfeed_23976 1 0 decap_w0
xfeed_23975 1 0 decap_w0
xfeed_23974 1 0 decap_w0
xfeed_23973 1 0 decap_w0
xfeed_23972 1 0 decap_w0
xfeed_23971 1 0 decap_w0
xfeed_23970 1 0 decap_w0
xfeed_19119 1 0 decap_w0
xfeed_19118 1 0 decap_w0
xfeed_19117 1 0 decap_w0
xfeed_19116 1 0 decap_w0
xfeed_19115 1 0 decap_w0
xfeed_19114 1 0 decap_w0
xfeed_19113 1 0 decap_w0
xfeed_19112 1 0 decap_w0
xfeed_19111 1 0 decap_w0
xfeed_17979 1 0 decap_w0
xfeed_17978 1 0 decap_w0
xfeed_17977 1 0 decap_w0
xfeed_17976 1 0 decap_w0
xfeed_17975 1 0 decap_w0
xfeed_17974 1 0 decap_w0
xfeed_17973 1 0 decap_w0
xfeed_17972 1 0 decap_w0
xfeed_17971 1 0 decap_w0
xfeed_17970 1 0 decap_w0
xfeed_14199 1 0 decap_w0
xfeed_14198 1 0 decap_w0
xfeed_14197 1 0 decap_w0
xfeed_14196 1 0 decap_w0
xfeed_14195 1 0 decap_w0
xfeed_14194 1 0 decap_w0
xfeed_14193 1 0 decap_w0
xfeed_14192 1 0 decap_w0
xfeed_14191 1 0 decap_w0
xfeed_14190 1 0 decap_w0
xfeed_13669 1 0 decap_w0
xfeed_13668 1 0 decap_w0
xfeed_13667 1 0 decap_w0
xfeed_13666 1 0 decap_w0
xfeed_13665 1 0 decap_w0
xfeed_13664 1 0 decap_w0
xfeed_13663 1 0 decap_w0
xfeed_13662 1 0 decap_w0
xfeed_13661 1 0 decap_w0
xfeed_13660 1 0 decap_w0
xfeed_3151 1 0 decap_w0
xfeed_3150 1 0 decap_w0
xfeed_31129 1 0 decap_w0
xfeed_31128 1 0 decap_w0
xfeed_31127 1 0 decap_w0
xfeed_31126 1 0 decap_w0
xfeed_31125 1 0 decap_w0
xfeed_31124 1 0 decap_w0
xfeed_31123 1 0 decap_w0
xfeed_31122 1 0 decap_w0
xfeed_31121 1 0 decap_w0
xfeed_31120 1 0 decap_w0
xfeed_29439 1 0 decap_w0
xfeed_29438 1 0 decap_w0
xfeed_29437 1 0 decap_w0
xfeed_29436 1 0 decap_w0
xfeed_29435 1 0 decap_w0
xfeed_29434 1 0 decap_w0
xfeed_29433 1 0 decap_w0
xfeed_29432 1 0 decap_w0
xfeed_29431 1 0 decap_w0
xfeed_29430 1 0 decap_w0
xfeed_28905 1 0 decap_w0
xfeed_28904 1 0 decap_w0
xfeed_28903 1 0 decap_w0
xfeed_28902 1 0 decap_w0
xfeed_28901 1 0 decap_w0
xfeed_28900 1 0 decap_w0
xfeed_25129 1 0 decap_w0
xfeed_25128 1 0 decap_w0
xfeed_25127 1 0 decap_w0
xfeed_25126 1 0 decap_w0
xfeed_25125 1 0 decap_w0
xfeed_25124 1 0 decap_w0
xfeed_25123 1 0 decap_w0
xfeed_25122 1 0 decap_w0
xfeed_25121 1 0 decap_w0
xfeed_25120 1 0 decap_w0
xfeed_7469 1 0 decap_w0
xfeed_7468 1 0 decap_w0
xfeed_7467 1 0 decap_w0
xfeed_7466 1 0 decap_w0
xfeed_7465 1 0 decap_w0
xfeed_7464 1 0 decap_w0
xfeed_7463 1 0 decap_w0
xfeed_7462 1 0 decap_w0
xfeed_7461 1 0 decap_w0
xfeed_7460 1 0 decap_w0
xfeed_6939 1 0 decap_w0
xfeed_6938 1 0 decap_w0
xfeed_6937 1 0 decap_w0
xfeed_6936 1 0 decap_w0
xfeed_6935 1 0 decap_w0
xfeed_6934 1 0 decap_w0
xfeed_6933 1 0 decap_w0
xfeed_6932 1 0 decap_w0
xfeed_6931 1 0 decap_w0
xfeed_6930 1 0 decap_w0
xfeed_3159 1 0 decap_w0
xfeed_3158 1 0 decap_w0
xfeed_3157 1 0 decap_w0
xfeed_3156 1 0 decap_w0
xfeed_3155 1 0 decap_w0
xfeed_3154 1 0 decap_w0
xfeed_3153 1 0 decap_w0
xfeed_3152 1 0 decap_w0
xfeed_2629 1 0 decap_w0
xfeed_2628 1 0 decap_w0
xfeed_2627 1 0 decap_w0
xfeed_2626 1 0 decap_w0
xfeed_2625 1 0 decap_w0
xfeed_2624 1 0 decap_w0
xfeed_2623 1 0 decap_w0
xfeed_2622 1 0 decap_w0
xfeed_2621 1 0 decap_w0
xfeed_2620 1 0 decap_w0
xfeed_609 1 0 decap_w0
xfeed_608 1 0 decap_w0
xfeed_607 1 0 decap_w0
xfeed_606 1 0 decap_w0
xfeed_605 1 0 decap_w0
xfeed_604 1 0 decap_w0
xfeed_603 1 0 decap_w0
xfeed_602 1 0 decap_w0
xfeed_601 1 0 decap_w0
xfeed_600 1 0 decap_w0
xfeed_28909 1 0 decap_w0
xfeed_28908 1 0 decap_w0
xfeed_28907 1 0 decap_w0
xfeed_28906 1 0 decap_w0
xfeed_23989 1 0 decap_w0
xfeed_23988 1 0 decap_w0
xfeed_23987 1 0 decap_w0
xfeed_23986 1 0 decap_w0
xfeed_23985 1 0 decap_w0
xfeed_23984 1 0 decap_w0
xfeed_23983 1 0 decap_w0
xfeed_23982 1 0 decap_w0
xfeed_23981 1 0 decap_w0
xfeed_23980 1 0 decap_w0
xfeed_19129 1 0 decap_w0
xfeed_19128 1 0 decap_w0
xfeed_19127 1 0 decap_w0
xfeed_19126 1 0 decap_w0
xfeed_19125 1 0 decap_w0
xfeed_19124 1 0 decap_w0
xfeed_19123 1 0 decap_w0
xfeed_19122 1 0 decap_w0
xfeed_19121 1 0 decap_w0
xfeed_19120 1 0 decap_w0
xfeed_17989 1 0 decap_w0
xfeed_17988 1 0 decap_w0
xfeed_17987 1 0 decap_w0
xfeed_17986 1 0 decap_w0
xfeed_17985 1 0 decap_w0
xfeed_17984 1 0 decap_w0
xfeed_17983 1 0 decap_w0
xfeed_17982 1 0 decap_w0
xfeed_17981 1 0 decap_w0
xfeed_17980 1 0 decap_w0
xfeed_13679 1 0 decap_w0
xfeed_13678 1 0 decap_w0
xfeed_13677 1 0 decap_w0
xfeed_13676 1 0 decap_w0
xfeed_13675 1 0 decap_w0
xfeed_13674 1 0 decap_w0
xfeed_13673 1 0 decap_w0
xfeed_13672 1 0 decap_w0
xfeed_13671 1 0 decap_w0
xfeed_13670 1 0 decap_w0
xsubckt_10_inv_x0 1 0 133 29 inv_x0
xfeed_31139 1 0 decap_w0
xfeed_31138 1 0 decap_w0
xfeed_31137 1 0 decap_w0
xfeed_31136 1 0 decap_w0
xfeed_31135 1 0 decap_w0
xfeed_31134 1 0 decap_w0
xfeed_31133 1 0 decap_w0
xfeed_31132 1 0 decap_w0
xfeed_31131 1 0 decap_w0
xfeed_31130 1 0 decap_w0
xfeed_30609 1 0 decap_w0
xfeed_30608 1 0 decap_w0
xfeed_30607 1 0 decap_w0
xfeed_30606 1 0 decap_w0
xfeed_30605 1 0 decap_w0
xfeed_30604 1 0 decap_w0
xfeed_30603 1 0 decap_w0
xfeed_30602 1 0 decap_w0
xfeed_30601 1 0 decap_w0
xfeed_30600 1 0 decap_w0
xfeed_29449 1 0 decap_w0
xfeed_29448 1 0 decap_w0
xfeed_29447 1 0 decap_w0
xfeed_29446 1 0 decap_w0
xfeed_29445 1 0 decap_w0
xfeed_29444 1 0 decap_w0
xfeed_29443 1 0 decap_w0
xfeed_29442 1 0 decap_w0
xfeed_29441 1 0 decap_w0
xfeed_29440 1 0 decap_w0
xfeed_28912 1 0 decap_w0
xfeed_28911 1 0 decap_w0
xfeed_28910 1 0 decap_w0
xfeed_25139 1 0 decap_w0
xfeed_25138 1 0 decap_w0
xfeed_25137 1 0 decap_w0
xfeed_25136 1 0 decap_w0
xfeed_25135 1 0 decap_w0
xfeed_25134 1 0 decap_w0
xfeed_25133 1 0 decap_w0
xfeed_25132 1 0 decap_w0
xfeed_25131 1 0 decap_w0
xfeed_25130 1 0 decap_w0
xfeed_24609 1 0 decap_w0
xfeed_24608 1 0 decap_w0
xfeed_24607 1 0 decap_w0
xfeed_24606 1 0 decap_w0
xfeed_24605 1 0 decap_w0
xfeed_24604 1 0 decap_w0
xfeed_24603 1 0 decap_w0
xfeed_24602 1 0 decap_w0
xfeed_24601 1 0 decap_w0
xfeed_24600 1 0 decap_w0
xfeed_7479 1 0 decap_w0
xfeed_7478 1 0 decap_w0
xfeed_7477 1 0 decap_w0
xfeed_7476 1 0 decap_w0
xfeed_7475 1 0 decap_w0
xfeed_7474 1 0 decap_w0
xfeed_7473 1 0 decap_w0
xfeed_7472 1 0 decap_w0
xfeed_7471 1 0 decap_w0
xfeed_7470 1 0 decap_w0
xfeed_6949 1 0 decap_w0
xfeed_6948 1 0 decap_w0
xfeed_6947 1 0 decap_w0
xfeed_6946 1 0 decap_w0
xfeed_6945 1 0 decap_w0
xfeed_6944 1 0 decap_w0
xfeed_6943 1 0 decap_w0
xfeed_6942 1 0 decap_w0
xfeed_6941 1 0 decap_w0
xfeed_6940 1 0 decap_w0
xfeed_3169 1 0 decap_w0
xfeed_3168 1 0 decap_w0
xfeed_3167 1 0 decap_w0
xfeed_3166 1 0 decap_w0
xfeed_3165 1 0 decap_w0
xfeed_3164 1 0 decap_w0
xfeed_3163 1 0 decap_w0
xfeed_3162 1 0 decap_w0
xfeed_3161 1 0 decap_w0
xfeed_3160 1 0 decap_w0
xfeed_2639 1 0 decap_w0
xfeed_2638 1 0 decap_w0
xfeed_2637 1 0 decap_w0
xfeed_2636 1 0 decap_w0
xfeed_2635 1 0 decap_w0
xfeed_2634 1 0 decap_w0
xfeed_2633 1 0 decap_w0
xfeed_2632 1 0 decap_w0
xfeed_2631 1 0 decap_w0
xfeed_2630 1 0 decap_w0
xfeed_619 1 0 decap_w0
xfeed_618 1 0 decap_w0
xfeed_617 1 0 decap_w0
xfeed_616 1 0 decap_w0
xfeed_615 1 0 decap_w0
xfeed_614 1 0 decap_w0
xfeed_613 1 0 decap_w0
xfeed_612 1 0 decap_w0
xfeed_611 1 0 decap_w0
xfeed_610 1 0 decap_w0
xsubckt_18_inv_x0 1 0 128 21 inv_x0
xfeed_28919 1 0 decap_w0
xfeed_28918 1 0 decap_w0
xfeed_28917 1 0 decap_w0
xfeed_28916 1 0 decap_w0
xfeed_28915 1 0 decap_w0
xfeed_28914 1 0 decap_w0
xfeed_28913 1 0 decap_w0
xfeed_23999 1 0 decap_w0
xfeed_23998 1 0 decap_w0
xfeed_23997 1 0 decap_w0
xfeed_23996 1 0 decap_w0
xfeed_23995 1 0 decap_w0
xfeed_23994 1 0 decap_w0
xfeed_23993 1 0 decap_w0
xfeed_23992 1 0 decap_w0
xfeed_23991 1 0 decap_w0
xfeed_23990 1 0 decap_w0
xfeed_19139 1 0 decap_w0
xfeed_19138 1 0 decap_w0
xfeed_19137 1 0 decap_w0
xfeed_19136 1 0 decap_w0
xfeed_19135 1 0 decap_w0
xfeed_19134 1 0 decap_w0
xfeed_19133 1 0 decap_w0
xfeed_19132 1 0 decap_w0
xfeed_19131 1 0 decap_w0
xfeed_19130 1 0 decap_w0
xfeed_18609 1 0 decap_w0
xfeed_18608 1 0 decap_w0
xfeed_18607 1 0 decap_w0
xfeed_18606 1 0 decap_w0
xfeed_18605 1 0 decap_w0
xfeed_18604 1 0 decap_w0
xfeed_18603 1 0 decap_w0
xfeed_18602 1 0 decap_w0
xfeed_18601 1 0 decap_w0
xfeed_18600 1 0 decap_w0
xfeed_17999 1 0 decap_w0
xfeed_17998 1 0 decap_w0
xfeed_17997 1 0 decap_w0
xfeed_17996 1 0 decap_w0
xfeed_17995 1 0 decap_w0
xfeed_17994 1 0 decap_w0
xfeed_17993 1 0 decap_w0
xfeed_17992 1 0 decap_w0
xfeed_17991 1 0 decap_w0
xfeed_17990 1 0 decap_w0
xfeed_13689 1 0 decap_w0
xfeed_13688 1 0 decap_w0
xfeed_13687 1 0 decap_w0
xfeed_13686 1 0 decap_w0
xfeed_13685 1 0 decap_w0
xfeed_13684 1 0 decap_w0
xfeed_13683 1 0 decap_w0
xfeed_13682 1 0 decap_w0
xfeed_13681 1 0 decap_w0
xfeed_13680 1 0 decap_w0
xfeed_31149 1 0 decap_w0
xfeed_31148 1 0 decap_w0
xfeed_31147 1 0 decap_w0
xfeed_31146 1 0 decap_w0
xfeed_31145 1 0 decap_w0
xfeed_31144 1 0 decap_w0
xfeed_31143 1 0 decap_w0
xfeed_31142 1 0 decap_w0
xfeed_31141 1 0 decap_w0
xfeed_31140 1 0 decap_w0
xfeed_30619 1 0 decap_w0
xfeed_30618 1 0 decap_w0
xfeed_30617 1 0 decap_w0
xfeed_30616 1 0 decap_w0
xfeed_30615 1 0 decap_w0
xfeed_30614 1 0 decap_w0
xfeed_30613 1 0 decap_w0
xfeed_30612 1 0 decap_w0
xfeed_30611 1 0 decap_w0
xfeed_30610 1 0 decap_w0
xfeed_29458 1 0 decap_w0
xfeed_29457 1 0 decap_w0
xfeed_29456 1 0 decap_w0
xfeed_29455 1 0 decap_w0
xfeed_29454 1 0 decap_w0
xfeed_29453 1 0 decap_w0
xfeed_29452 1 0 decap_w0
xfeed_29451 1 0 decap_w0
xfeed_29450 1 0 decap_w0
xfeed_25149 1 0 decap_w0
xfeed_25148 1 0 decap_w0
xfeed_25147 1 0 decap_w0
xfeed_25146 1 0 decap_w0
xfeed_25145 1 0 decap_w0
xfeed_25144 1 0 decap_w0
xfeed_25143 1 0 decap_w0
xfeed_25142 1 0 decap_w0
xfeed_25141 1 0 decap_w0
xfeed_25140 1 0 decap_w0
xfeed_24619 1 0 decap_w0
xfeed_24618 1 0 decap_w0
xfeed_24617 1 0 decap_w0
xfeed_24616 1 0 decap_w0
xfeed_24615 1 0 decap_w0
xfeed_24614 1 0 decap_w0
xfeed_24613 1 0 decap_w0
xfeed_24612 1 0 decap_w0
xfeed_24611 1 0 decap_w0
xfeed_24610 1 0 decap_w0
xfeed_20309 1 0 decap_w0
xfeed_20308 1 0 decap_w0
xfeed_20307 1 0 decap_w0
xfeed_20306 1 0 decap_w0
xfeed_20305 1 0 decap_w0
xfeed_20304 1 0 decap_w0
xfeed_20303 1 0 decap_w0
xfeed_20302 1 0 decap_w0
xfeed_20301 1 0 decap_w0
xfeed_20300 1 0 decap_w0
xfeed_7489 1 0 decap_w0
xfeed_7488 1 0 decap_w0
xfeed_7487 1 0 decap_w0
xfeed_7486 1 0 decap_w0
xfeed_7485 1 0 decap_w0
xfeed_7484 1 0 decap_w0
xfeed_7483 1 0 decap_w0
xfeed_7482 1 0 decap_w0
xfeed_7481 1 0 decap_w0
xfeed_7480 1 0 decap_w0
xfeed_6959 1 0 decap_w0
xfeed_6958 1 0 decap_w0
xfeed_6957 1 0 decap_w0
xfeed_6956 1 0 decap_w0
xfeed_6955 1 0 decap_w0
xfeed_6954 1 0 decap_w0
xfeed_6953 1 0 decap_w0
xfeed_6952 1 0 decap_w0
xfeed_6951 1 0 decap_w0
xfeed_6950 1 0 decap_w0
xfeed_3179 1 0 decap_w0
xfeed_3178 1 0 decap_w0
xfeed_3177 1 0 decap_w0
xfeed_3176 1 0 decap_w0
xfeed_3175 1 0 decap_w0
xfeed_3174 1 0 decap_w0
xfeed_3173 1 0 decap_w0
xfeed_3172 1 0 decap_w0
xfeed_3171 1 0 decap_w0
xfeed_3170 1 0 decap_w0
xfeed_2649 1 0 decap_w0
xfeed_2648 1 0 decap_w0
xfeed_2647 1 0 decap_w0
xfeed_2646 1 0 decap_w0
xfeed_2645 1 0 decap_w0
xfeed_2644 1 0 decap_w0
xfeed_2643 1 0 decap_w0
xfeed_2642 1 0 decap_w0
xfeed_2641 1 0 decap_w0
xfeed_2640 1 0 decap_w0
xfeed_629 1 0 decap_w0
xfeed_628 1 0 decap_w0
xfeed_627 1 0 decap_w0
xfeed_626 1 0 decap_w0
xfeed_625 1 0 decap_w0
xfeed_624 1 0 decap_w0
xfeed_623 1 0 decap_w0
xfeed_622 1 0 decap_w0
xfeed_621 1 0 decap_w0
xfeed_620 1 0 decap_w0
xfeed_29459 1 0 decap_w0
xfeed_28929 1 0 decap_w0
xfeed_28928 1 0 decap_w0
xfeed_28927 1 0 decap_w0
xfeed_28926 1 0 decap_w0
xfeed_28925 1 0 decap_w0
xfeed_28924 1 0 decap_w0
xfeed_28923 1 0 decap_w0
xfeed_28922 1 0 decap_w0
xfeed_28921 1 0 decap_w0
xfeed_28920 1 0 decap_w0
xfeed_19149 1 0 decap_w0
xfeed_19148 1 0 decap_w0
xfeed_19147 1 0 decap_w0
xfeed_19146 1 0 decap_w0
xfeed_19145 1 0 decap_w0
xfeed_19144 1 0 decap_w0
xfeed_19143 1 0 decap_w0
xfeed_19142 1 0 decap_w0
xfeed_19141 1 0 decap_w0
xfeed_19140 1 0 decap_w0
xfeed_18619 1 0 decap_w0
xfeed_18618 1 0 decap_w0
xfeed_18617 1 0 decap_w0
xfeed_18616 1 0 decap_w0
xfeed_18615 1 0 decap_w0
xfeed_18614 1 0 decap_w0
xfeed_18613 1 0 decap_w0
xfeed_18612 1 0 decap_w0
xfeed_18611 1 0 decap_w0
xfeed_18610 1 0 decap_w0
xfeed_14309 1 0 decap_w0
xfeed_14308 1 0 decap_w0
xfeed_14307 1 0 decap_w0
xfeed_14306 1 0 decap_w0
xfeed_14305 1 0 decap_w0
xfeed_14304 1 0 decap_w0
xfeed_14303 1 0 decap_w0
xfeed_14302 1 0 decap_w0
xfeed_14301 1 0 decap_w0
xfeed_14300 1 0 decap_w0
xfeed_13699 1 0 decap_w0
xfeed_13698 1 0 decap_w0
xfeed_13697 1 0 decap_w0
xfeed_13696 1 0 tie
xfeed_13695 1 0 decap_w0
xfeed_13694 1 0 decap_w0
xfeed_13693 1 0 decap_w0
xfeed_13692 1 0 decap_w0
xfeed_13691 1 0 decap_w0
xfeed_13690 1 0 decap_w0
xfeed_8109 1 0 decap_w0
xfeed_8108 1 0 decap_w0
xfeed_8107 1 0 decap_w0
xfeed_8106 1 0 decap_w0
xfeed_8105 1 0 decap_w0
xfeed_8104 1 0 decap_w0
xfeed_8103 1 0 decap_w0
xfeed_8102 1 0 decap_w0
xfeed_8101 1 0 decap_w0
xfeed_8100 1 0 decap_w0
xfeed_31159 1 0 decap_w0
xfeed_31158 1 0 decap_w0
xfeed_31157 1 0 decap_w0
xfeed_31156 1 0 decap_w0
xfeed_31155 1 0 decap_w0
xfeed_31154 1 0 decap_w0
xfeed_31153 1 0 decap_w0
xfeed_31152 1 0 decap_w0
xfeed_31151 1 0 decap_w0
xfeed_31150 1 0 decap_w0
xfeed_30629 1 0 decap_w0
xfeed_30628 1 0 decap_w0
xfeed_30627 1 0 decap_w0
xfeed_30626 1 0 decap_w0
xfeed_30625 1 0 decap_w0
xfeed_30624 1 0 decap_w0
xfeed_30623 1 0 decap_w0
xfeed_30622 1 0 decap_w0
xfeed_30621 1 0 decap_w0
xfeed_30620 1 0 decap_w0
xfeed_29465 1 0 decap_w0
xfeed_29464 1 0 decap_w0
xfeed_29463 1 0 decap_w0
xfeed_29462 1 0 decap_w0
xfeed_29461 1 0 decap_w0
xfeed_29460 1 0 decap_w0
xfeed_25159 1 0 decap_w0
xfeed_25158 1 0 decap_w0
xfeed_25157 1 0 decap_w0
xfeed_25156 1 0 decap_w0
xfeed_25155 1 0 decap_w0
xfeed_25154 1 0 decap_w0
xfeed_25153 1 0 decap_w0
xfeed_25152 1 0 decap_w0
xfeed_25151 1 0 decap_w0
xfeed_25150 1 0 decap_w0
xfeed_24626 1 0 decap_w0
xfeed_24625 1 0 decap_w0
xfeed_24624 1 0 decap_w0
xfeed_24623 1 0 decap_w0
xfeed_24622 1 0 decap_w0
xfeed_24621 1 0 decap_w0
xfeed_24620 1 0 decap_w0
xfeed_20319 1 0 decap_w0
xfeed_20318 1 0 decap_w0
xfeed_20317 1 0 decap_w0
xfeed_20316 1 0 decap_w0
xfeed_20315 1 0 decap_w0
xfeed_20314 1 0 decap_w0
xfeed_20313 1 0 decap_w0
xfeed_20312 1 0 decap_w0
xfeed_20311 1 0 decap_w0
xfeed_20310 1 0 decap_w0
xfeed_7499 1 0 decap_w0
xfeed_7498 1 0 decap_w0
xfeed_7497 1 0 decap_w0
xfeed_7496 1 0 decap_w0
xfeed_7495 1 0 decap_w0
xfeed_7494 1 0 decap_w0
xfeed_7493 1 0 decap_w0
xfeed_7492 1 0 decap_w0
xfeed_7491 1 0 decap_w0
xfeed_7490 1 0 decap_w0
xfeed_6969 1 0 decap_w0
xfeed_6968 1 0 decap_w0
xfeed_6967 1 0 decap_w0
xfeed_6966 1 0 decap_w0
xfeed_6965 1 0 decap_w0
xfeed_6964 1 0 decap_w0
xfeed_6963 1 0 decap_w0
xfeed_6962 1 0 decap_w0
xfeed_6961 1 0 decap_w0
xfeed_6960 1 0 decap_w0
xfeed_3189 1 0 decap_w0
xfeed_3188 1 0 decap_w0
xfeed_3187 1 0 decap_w0
xfeed_3186 1 0 decap_w0
xfeed_3185 1 0 decap_w0
xfeed_3184 1 0 decap_w0
xfeed_3183 1 0 decap_w0
xfeed_3182 1 0 decap_w0
xfeed_3181 1 0 decap_w0
xfeed_3180 1 0 decap_w0
xfeed_2659 1 0 decap_w0
xfeed_2658 1 0 decap_w0
xfeed_2657 1 0 decap_w0
xfeed_2656 1 0 decap_w0
xfeed_2655 1 0 decap_w0
xfeed_2654 1 0 decap_w0
xfeed_2653 1 0 decap_w0
xfeed_2652 1 0 decap_w0
xfeed_2651 1 0 decap_w0
xfeed_2650 1 0 decap_w0
xfeed_639 1 0 decap_w0
xfeed_638 1 0 decap_w0
xfeed_637 1 0 decap_w0
xfeed_636 1 0 decap_w0
xfeed_635 1 0 decap_w0
xfeed_634 1 0 decap_w0
xfeed_633 1 0 decap_w0
xfeed_632 1 0 decap_w0
xfeed_631 1 0 decap_w0
xfeed_630 1 0 decap_w0
xfeed_29469 1 0 decap_w0
xfeed_29468 1 0 decap_w0
xfeed_29467 1 0 decap_w0
xfeed_29466 1 0 decap_w0
xfeed_28939 1 0 decap_w0
xfeed_28938 1 0 decap_w0
xfeed_28937 1 0 decap_w0
xfeed_28936 1 0 decap_w0
xfeed_28935 1 0 decap_w0
xfeed_28934 1 0 decap_w0
xfeed_28933 1 0 decap_w0
xfeed_28932 1 0 decap_w0
xfeed_28931 1 0 decap_w0
xfeed_28930 1 0 decap_w0
xfeed_24629 1 0 decap_w0
xfeed_24628 1 0 decap_w0
xfeed_24627 1 0 decap_w0
xfeed_19159 1 0 decap_w0
xfeed_19158 1 0 decap_w0
xfeed_19157 1 0 decap_w0
xfeed_19156 1 0 decap_w0
xfeed_19155 1 0 decap_w0
xfeed_19154 1 0 decap_w0
xfeed_19153 1 0 decap_w0
xfeed_19152 1 0 decap_w0
xfeed_19151 1 0 decap_w0
xfeed_19150 1 0 decap_w0
xfeed_18629 1 0 decap_w0
xfeed_18628 1 0 decap_w0
xfeed_18627 1 0 decap_w0
xfeed_18626 1 0 decap_w0
xfeed_18625 1 0 decap_w0
xfeed_18624 1 0 decap_w0
xfeed_18623 1 0 decap_w0
xfeed_18622 1 0 decap_w0
xfeed_18621 1 0 decap_w0
xfeed_18620 1 0 decap_w0
xfeed_14319 1 0 decap_w0
xfeed_14318 1 0 decap_w0
xfeed_14317 1 0 decap_w0
xfeed_14316 1 0 decap_w0
xfeed_14315 1 0 decap_w0
xfeed_14314 1 0 decap_w0
xfeed_14313 1 0 decap_w0
xfeed_14312 1 0 decap_w0
xfeed_14311 1 0 decap_w0
xfeed_14310 1 0 decap_w0
xfeed_10009 1 0 decap_w0
xfeed_10008 1 0 decap_w0
xfeed_10007 1 0 decap_w0
xfeed_10006 1 0 decap_w0
xfeed_10005 1 0 decap_w0
xfeed_10004 1 0 decap_w0
xfeed_10003 1 0 decap_w0
xfeed_10002 1 0 decap_w0
xfeed_10001 1 0 decap_w0
xfeed_10000 1 0 decap_w0
xfeed_8116 1 0 decap_w0
xfeed_8115 1 0 decap_w0
xfeed_8114 1 0 decap_w0
xfeed_8113 1 0 decap_w0
xfeed_8112 1 0 decap_w0
xfeed_8111 1 0 decap_w0
xfeed_8110 1 0 decap_w0
xfeed_31169 1 0 decap_w0
xfeed_31168 1 0 decap_w0
xfeed_31167 1 0 decap_w0
xfeed_31166 1 0 decap_w0
xfeed_31165 1 0 decap_w0
xfeed_31164 1 0 decap_w0
xfeed_31163 1 0 decap_w0
xfeed_31162 1 0 decap_w0
xfeed_31161 1 0 decap_w0
xfeed_31160 1 0 decap_w0
xfeed_30639 1 0 decap_w0
xfeed_30638 1 0 decap_w0
xfeed_30637 1 0 decap_w0
xfeed_30636 1 0 decap_w0
xfeed_30635 1 0 decap_w0
xfeed_30634 1 0 decap_w0
xfeed_30633 1 0 decap_w0
xfeed_30632 1 0 decap_w0
xfeed_30631 1 0 decap_w0
xfeed_30630 1 0 decap_w0
xfeed_29472 1 0 decap_w0
xfeed_29471 1 0 decap_w0
xfeed_29470 1 0 decap_w0
xfeed_25169 1 0 decap_w0
xfeed_25168 1 0 decap_w0
xfeed_25167 1 0 decap_w0
xfeed_25166 1 0 decap_w0
xfeed_25165 1 0 decap_w0
xfeed_25164 1 0 decap_w0
xfeed_25163 1 0 decap_w0
xfeed_25162 1 0 decap_w0
xfeed_25161 1 0 decap_w0
xfeed_25160 1 0 decap_w0
xfeed_24633 1 0 decap_w0
xfeed_24632 1 0 decap_w0
xfeed_24631 1 0 decap_w0
xfeed_24630 1 0 decap_w0
xfeed_20329 1 0 decap_w0
xfeed_20328 1 0 decap_w0
xfeed_20327 1 0 decap_w0
xfeed_20326 1 0 decap_w0
xfeed_20325 1 0 decap_w0
xfeed_20324 1 0 decap_w0
xfeed_20323 1 0 decap_w0
xfeed_20322 1 0 decap_w0
xfeed_20321 1 0 decap_w0
xfeed_20320 1 0 decap_w0
xfeed_8119 1 0 decap_w0
xfeed_8118 1 0 decap_w0
xfeed_8117 1 0 decap_w0
xfeed_6979 1 0 decap_w0
xfeed_6978 1 0 decap_w0
xfeed_6977 1 0 decap_w0
xfeed_6976 1 0 decap_w0
xfeed_6975 1 0 decap_w0
xfeed_6974 1 0 decap_w0
xfeed_6973 1 0 decap_w0
xfeed_6972 1 0 decap_w0
xfeed_6971 1 0 decap_w0
xfeed_6970 1 0 decap_w0
xfeed_3199 1 0 decap_w0
xfeed_3198 1 0 decap_w0
xfeed_3197 1 0 decap_w0
xfeed_3196 1 0 decap_w0
xfeed_3195 1 0 decap_w0
xfeed_3194 1 0 decap_w0
xfeed_3193 1 0 decap_w0
xfeed_3192 1 0 decap_w0
xfeed_3191 1 0 decap_w0
xfeed_3190 1 0 decap_w0
xfeed_2669 1 0 decap_w0
xfeed_2668 1 0 decap_w0
xfeed_2667 1 0 decap_w0
xfeed_2666 1 0 decap_w0
xfeed_2665 1 0 decap_w0
xfeed_2664 1 0 decap_w0
xfeed_2663 1 0 decap_w0
xfeed_2662 1 0 decap_w0
xfeed_2661 1 0 decap_w0
xfeed_2660 1 0 decap_w0
xfeed_646 1 0 decap_w0
xfeed_645 1 0 decap_w0
xfeed_644 1 0 decap_w0
xfeed_643 1 0 decap_w0
xfeed_642 1 0 decap_w0
xfeed_641 1 0 decap_w0
xfeed_640 1 0 decap_w0
xfeed_29479 1 0 decap_w0
xfeed_29478 1 0 decap_w0
xfeed_29477 1 0 decap_w0
xfeed_29476 1 0 decap_w0
xfeed_29475 1 0 decap_w0
xfeed_29474 1 0 decap_w0
xfeed_29473 1 0 decap_w0
xfeed_28949 1 0 decap_w0
xfeed_28948 1 0 decap_w0
xfeed_28947 1 0 decap_w0
xfeed_28946 1 0 decap_w0
xfeed_28945 1 0 decap_w0
xfeed_28944 1 0 decap_w0
xfeed_28943 1 0 decap_w0
xfeed_28942 1 0 decap_w0
xfeed_28941 1 0 decap_w0
xfeed_28940 1 0 decap_w0
xfeed_24639 1 0 decap_w0
xfeed_24638 1 0 decap_w0
xfeed_24637 1 0 decap_w0
xfeed_24636 1 0 decap_w0
xfeed_24635 1 0 decap_w0
xfeed_24634 1 0 decap_w0
xfeed_19169 1 0 decap_w0
xfeed_19168 1 0 decap_w0
xfeed_19167 1 0 decap_w0
xfeed_19166 1 0 decap_w0
xfeed_19165 1 0 decap_w0
xfeed_19164 1 0 decap_w0
xfeed_19163 1 0 decap_w0
xfeed_19162 1 0 decap_w0
xfeed_19161 1 0 decap_w0
xfeed_19160 1 0 decap_w0
xfeed_18639 1 0 decap_w0
xfeed_18638 1 0 decap_w0
xfeed_18637 1 0 decap_w0
xfeed_18636 1 0 decap_w0
xfeed_18635 1 0 decap_w0
xfeed_18634 1 0 decap_w0
xfeed_18633 1 0 decap_w0
xfeed_18632 1 0 decap_w0
xfeed_18631 1 0 decap_w0
xfeed_18630 1 0 decap_w0
xfeed_14329 1 0 decap_w0
xfeed_14328 1 0 decap_w0
xfeed_14327 1 0 decap_w0
xfeed_14326 1 0 decap_w0
xfeed_14325 1 0 decap_w0
xfeed_14324 1 0 decap_w0
xfeed_14323 1 0 decap_w0
xfeed_14322 1 0 decap_w0
xfeed_14321 1 0 decap_w0
xfeed_14320 1 0 decap_w0
xfeed_10019 1 0 decap_w0
xfeed_10018 1 0 decap_w0
xfeed_10017 1 0 decap_w0
xfeed_10016 1 0 decap_w0
xfeed_10015 1 0 decap_w0
xfeed_10014 1 0 decap_w0
xfeed_10013 1 0 decap_w0
xfeed_10012 1 0 decap_w0
xfeed_10011 1 0 decap_w0
xfeed_10010 1 0 decap_w0
xfeed_8123 1 0 decap_w0
xfeed_8122 1 0 decap_w0
xfeed_8121 1 0 decap_w0
xfeed_8120 1 0 decap_w0
xfeed_649 1 0 decap_w0
xfeed_648 1 0 decap_w0
xfeed_647 1 0 decap_w0
xfeed_31179 1 0 decap_w0
xfeed_31178 1 0 decap_w0
xfeed_31177 1 0 decap_w0
xfeed_31176 1 0 decap_w0
xfeed_31175 1 0 decap_w0
xfeed_31174 1 0 decap_w0
xfeed_31173 1 0 decap_w0
xfeed_31172 1 0 decap_w0
xfeed_31171 1 0 decap_w0
xfeed_31170 1 0 decap_w0
xfeed_30649 1 0 decap_w0
xfeed_30648 1 0 decap_w0
xfeed_30647 1 0 decap_w0
xfeed_30646 1 0 decap_w0
xfeed_30645 1 0 decap_w0
xfeed_30644 1 0 decap_w0
xfeed_30643 1 0 decap_w0
xfeed_30642 1 0 decap_w0
xfeed_30641 1 0 decap_w0
xfeed_30640 1 0 decap_w0
xfeed_25179 1 0 decap_w0
xfeed_25178 1 0 decap_w0
xfeed_25177 1 0 decap_w0
xfeed_25176 1 0 decap_w0
xfeed_25175 1 0 decap_w0
xfeed_25174 1 0 decap_w0
xfeed_25173 1 0 decap_w0
xfeed_25172 1 0 decap_w0
xfeed_25171 1 0 decap_w0
xfeed_25170 1 0 decap_w0
xfeed_24640 1 0 decap_w0
xfeed_20339 1 0 decap_w0
xfeed_20338 1 0 decap_w0
xfeed_20337 1 0 decap_w0
xfeed_20336 1 0 decap_w0
xfeed_20335 1 0 decap_w0
xfeed_20334 1 0 decap_w0
xfeed_20333 1 0 decap_w0
xfeed_20332 1 0 decap_w0
xfeed_20331 1 0 decap_w0
xfeed_20330 1 0 decap_w0
xfeed_8129 1 0 decap_w0
xfeed_8128 1 0 decap_w0
xfeed_8127 1 0 tie
xfeed_8126 1 0 decap_w0
xfeed_8125 1 0 decap_w0
xfeed_8124 1 0 decap_w0
xfeed_6989 1 0 decap_w0
xfeed_6988 1 0 decap_w0
xfeed_6987 1 0 decap_w0
xfeed_6986 1 0 decap_w0
xfeed_6985 1 0 decap_w0
xfeed_6984 1 0 decap_w0
xfeed_6983 1 0 decap_w0
xfeed_6982 1 0 decap_w0
xfeed_6981 1 0 decap_w0
xfeed_6980 1 0 decap_w0
xfeed_2679 1 0 decap_w0
xfeed_2678 1 0 decap_w0
xfeed_2677 1 0 decap_w0
xfeed_2676 1 0 decap_w0
xfeed_2675 1 0 decap_w0
xfeed_2674 1 0 decap_w0
xfeed_2673 1 0 decap_w0
xfeed_2672 1 0 decap_w0
xfeed_2671 1 0 decap_w0
xfeed_2670 1 0 decap_w0
xfeed_653 1 0 decap_w0
xfeed_652 1 0 decap_w0
xfeed_651 1 0 decap_w0
xfeed_650 1 0 decap_w0
xfeed_29489 1 0 decap_w0
xfeed_29488 1 0 decap_w0
xfeed_29487 1 0 decap_w0
xfeed_29486 1 0 decap_w0
xfeed_29485 1 0 decap_w0
xfeed_29484 1 0 decap_w0
xfeed_29483 1 0 decap_w0
xfeed_29482 1 0 decap_w0
xfeed_29481 1 0 decap_w0
xfeed_29480 1 0 decap_w0
xfeed_28959 1 0 decap_w0
xfeed_28958 1 0 decap_w0
xfeed_28957 1 0 decap_w0
xfeed_28956 1 0 decap_w0
xfeed_28955 1 0 decap_w0
xfeed_28954 1 0 decap_w0
xfeed_28953 1 0 decap_w0
xfeed_28952 1 0 decap_w0
xfeed_28951 1 0 decap_w0
xfeed_28950 1 0 decap_w0
xfeed_24649 1 0 decap_w0
xfeed_24648 1 0 decap_w0
xfeed_24647 1 0 decap_w0
xfeed_24646 1 0 decap_w0
xfeed_24645 1 0 decap_w0
xfeed_24644 1 0 decap_w0
xfeed_24643 1 0 decap_w0
xfeed_24642 1 0 decap_w0
xfeed_24641 1 0 decap_w0
xfeed_19179 1 0 decap_w0
xfeed_19178 1 0 decap_w0
xfeed_19177 1 0 decap_w0
xfeed_19176 1 0 decap_w0
xfeed_19175 1 0 decap_w0
xfeed_19174 1 0 decap_w0
xfeed_19173 1 0 decap_w0
xfeed_19172 1 0 decap_w0
xfeed_19171 1 0 decap_w0
xfeed_19170 1 0 decap_w0
xfeed_18649 1 0 decap_w0
xfeed_18648 1 0 decap_w0
xfeed_18647 1 0 decap_w0
xfeed_18646 1 0 decap_w0
xfeed_18645 1 0 decap_w0
xfeed_18644 1 0 decap_w0
xfeed_18643 1 0 decap_w0
xfeed_18642 1 0 decap_w0
xfeed_18641 1 0 decap_w0
xfeed_18640 1 0 decap_w0
xfeed_14339 1 0 decap_w0
xfeed_14338 1 0 decap_w0
xfeed_14337 1 0 decap_w0
xfeed_14336 1 0 decap_w0
xfeed_14335 1 0 decap_w0
xfeed_14334 1 0 decap_w0
xfeed_14333 1 0 decap_w0
xfeed_14332 1 0 decap_w0
xfeed_14331 1 0 decap_w0
xfeed_14330 1 0 decap_w0
xfeed_13809 1 0 decap_w0
xfeed_13808 1 0 decap_w0
xfeed_13807 1 0 decap_w0
xfeed_13806 1 0 decap_w0
xfeed_13805 1 0 decap_w0
xfeed_13804 1 0 decap_w0
xfeed_13803 1 0 decap_w0
xfeed_13802 1 0 decap_w0
xfeed_13801 1 0 decap_w0
xfeed_13800 1 0 decap_w0
xfeed_10029 1 0 decap_w0
xfeed_10028 1 0 decap_w0
xfeed_10027 1 0 decap_w0
xfeed_10026 1 0 decap_w0
xfeed_10025 1 0 decap_w0
xfeed_10024 1 0 decap_w0
xfeed_10023 1 0 decap_w0
xfeed_10022 1 0 decap_w0
xfeed_10021 1 0 decap_w0
xfeed_10020 1 0 decap_w0
xfeed_8130 1 0 decap_w0
xfeed_659 1 0 decap_w0
xfeed_658 1 0 decap_w0
xfeed_657 1 0 decap_w0
xfeed_656 1 0 decap_w0
xfeed_655 1 0 decap_w0
xfeed_654 1 0 decap_w0
xfeed_31189 1 0 decap_w0
xfeed_31188 1 0 decap_w0
xfeed_31187 1 0 decap_w0
xfeed_31186 1 0 decap_w0
xfeed_31185 1 0 decap_w0
xfeed_31184 1 0 decap_w0
xfeed_31183 1 0 decap_w0
xfeed_31182 1 0 decap_w0
xfeed_31181 1 0 decap_w0
xfeed_31180 1 0 decap_w0
xfeed_30659 1 0 decap_w0
xfeed_30658 1 0 decap_w0
xfeed_30657 1 0 decap_w0
xfeed_30656 1 0 decap_w0
xfeed_30655 1 0 decap_w0
xfeed_30654 1 0 decap_w0
xfeed_30653 1 0 decap_w0
xfeed_30652 1 0 decap_w0
xfeed_30651 1 0 decap_w0
xfeed_30650 1 0 decap_w0
xfeed_25186 1 0 decap_w0
xfeed_25185 1 0 decap_w0
xfeed_25184 1 0 decap_w0
xfeed_25183 1 0 decap_w0
xfeed_25182 1 0 decap_w0
xfeed_25181 1 0 decap_w0
xfeed_25180 1 0 decap_w0
xfeed_20347 1 0 decap_w0
xfeed_20346 1 0 decap_w0
xfeed_20345 1 0 decap_w0
xfeed_20344 1 0 decap_w0
xfeed_20343 1 0 decap_w0
xfeed_20342 1 0 decap_w0
xfeed_20341 1 0 decap_w0
xfeed_20340 1 0 decap_w0
xfeed_8139 1 0 decap_w0
xfeed_8138 1 0 decap_w0
xfeed_8137 1 0 decap_w0
xfeed_8136 1 0 decap_w0
xfeed_8135 1 0 decap_w0
xfeed_8134 1 0 decap_w0
xfeed_8133 1 0 decap_w0
xfeed_8132 1 0 decap_w0
xfeed_8131 1 0 decap_w0
xfeed_7609 1 0 decap_w0
xfeed_7608 1 0 decap_w0
xfeed_7607 1 0 decap_w0
xfeed_7606 1 0 decap_w0
xfeed_7605 1 0 decap_w0
xfeed_7604 1 0 decap_w0
xfeed_7603 1 0 decap_w0
xfeed_7602 1 0 decap_w0
xfeed_7601 1 0 decap_w0
xfeed_7600 1 0 decap_w0
xfeed_6999 1 0 decap_w0
xfeed_6998 1 0 decap_w0
xfeed_6997 1 0 decap_w0
xfeed_6996 1 0 decap_w0
xfeed_6995 1 0 decap_w0
xfeed_6994 1 0 decap_w0
xfeed_6993 1 0 decap_w0
xfeed_6992 1 0 decap_w0
xfeed_6991 1 0 decap_w0
xfeed_6990 1 0 decap_w0
xfeed_2689 1 0 decap_w0
xfeed_2688 1 0 decap_w0
xfeed_2687 1 0 decap_w0
xfeed_2686 1 0 decap_w0
xfeed_2685 1 0 decap_w0
xfeed_2684 1 0 decap_w0
xfeed_2683 1 0 decap_w0
xfeed_2682 1 0 decap_w0
xfeed_2681 1 0 decap_w0
xfeed_2680 1 0 decap_w0
xfeed_660 1 0 decap_w0
xfeed_29499 1 0 decap_w0
xfeed_29498 1 0 decap_w0
xfeed_29497 1 0 decap_w0
xfeed_29496 1 0 decap_w0
xfeed_29495 1 0 decap_w0
xfeed_29494 1 0 decap_w0
xfeed_29493 1 0 decap_w0
xfeed_29492 1 0 decap_w0
xfeed_29491 1 0 decap_w0
xfeed_29490 1 0 decap_w0
xfeed_28969 1 0 decap_w0
xfeed_28968 1 0 decap_w0
xfeed_28967 1 0 decap_w0
xfeed_28966 1 0 decap_w0
xfeed_28965 1 0 decap_w0
xfeed_28964 1 0 decap_w0
xfeed_28963 1 0 decap_w0
xfeed_28962 1 0 decap_w0
xfeed_28961 1 0 decap_w0
xfeed_28960 1 0 decap_w0
xfeed_25189 1 0 decap_w0
xfeed_25188 1 0 decap_w0
xfeed_25187 1 0 decap_w0
xfeed_24659 1 0 decap_w0
xfeed_24658 1 0 decap_w0
xfeed_24657 1 0 decap_w0
xfeed_24656 1 0 decap_w0
xfeed_24655 1 0 decap_w0
xfeed_24654 1 0 decap_w0
xfeed_24653 1 0 decap_w0
xfeed_24652 1 0 decap_w0
xfeed_24651 1 0 decap_w0
xfeed_24650 1 0 decap_w0
xfeed_20349 1 0 decap_w0
xfeed_20348 1 0 decap_w0
xfeed_19189 1 0 decap_w0
xfeed_19188 1 0 decap_w0
xfeed_19187 1 0 decap_w0
xfeed_19186 1 0 decap_w0
xfeed_19185 1 0 decap_w0
xfeed_19184 1 0 decap_w0
xfeed_19183 1 0 decap_w0
xfeed_19182 1 0 decap_w0
xfeed_19181 1 0 decap_w0
xfeed_19180 1 0 decap_w0
xfeed_18659 1 0 decap_w0
xfeed_18658 1 0 decap_w0
xfeed_18657 1 0 decap_w0
xfeed_18656 1 0 decap_w0
xfeed_18655 1 0 decap_w0
xfeed_18654 1 0 decap_w0
xfeed_18653 1 0 decap_w0
xfeed_18652 1 0 decap_w0
xfeed_18651 1 0 decap_w0
xfeed_18650 1 0 decap_w0
xfeed_14349 1 0 decap_w0
xfeed_14348 1 0 decap_w0
xfeed_14347 1 0 decap_w0
xfeed_14346 1 0 decap_w0
xfeed_14345 1 0 decap_w0
xfeed_14344 1 0 decap_w0
xfeed_14343 1 0 decap_w0
xfeed_14342 1 0 decap_w0
xfeed_14341 1 0 decap_w0
xfeed_14340 1 0 decap_w0
xfeed_13819 1 0 decap_w0
xfeed_13818 1 0 decap_w0
xfeed_13817 1 0 decap_w0
xfeed_13816 1 0 decap_w0
xfeed_13815 1 0 decap_w0
xfeed_13814 1 0 decap_w0
xfeed_13813 1 0 decap_w0
xfeed_13812 1 0 decap_w0
xfeed_13811 1 0 decap_w0
xfeed_13810 1 0 decap_w0
xfeed_10039 1 0 decap_w0
xfeed_10038 1 0 decap_w0
xfeed_10037 1 0 decap_w0
xfeed_10036 1 0 decap_w0
xfeed_10035 1 0 decap_w0
xfeed_10034 1 0 decap_w0
xfeed_10033 1 0 decap_w0
xfeed_10032 1 0 decap_w0
xfeed_10031 1 0 decap_w0
xfeed_10030 1 0 decap_w0
xfeed_669 1 0 decap_w0
xfeed_668 1 0 decap_w0
xfeed_667 1 0 decap_w0
xfeed_666 1 0 decap_w0
xfeed_665 1 0 decap_w0
xfeed_664 1 0 decap_w0
xfeed_663 1 0 decap_w0
xfeed_662 1 0 decap_w0
xfeed_661 1 0 decap_w0
xfeed_31199 1 0 decap_w0
xfeed_31198 1 0 decap_w0
xfeed_31197 1 0 decap_w0
xfeed_31196 1 0 decap_w0
xfeed_31195 1 0 decap_w0
xfeed_31194 1 0 decap_w0
xfeed_31193 1 0 decap_w0
xfeed_31192 1 0 decap_w0
xfeed_31191 1 0 decap_w0
xfeed_31190 1 0 decap_w0
xfeed_30669 1 0 decap_w0
xfeed_30668 1 0 decap_w0
xfeed_30667 1 0 decap_w0
xfeed_30666 1 0 decap_w0
xfeed_30665 1 0 decap_w0
xfeed_30664 1 0 decap_w0
xfeed_30663 1 0 decap_w0
xfeed_30662 1 0 decap_w0
xfeed_30661 1 0 decap_w0
xfeed_30660 1 0 decap_w0
xfeed_25193 1 0 decap_w0
xfeed_25192 1 0 decap_w0
xfeed_25191 1 0 decap_w0
xfeed_25190 1 0 decap_w0
xfeed_20354 1 0 decap_w0
xfeed_20353 1 0 decap_w0
xfeed_20352 1 0 decap_w0
xfeed_20351 1 0 decap_w0
xfeed_20350 1 0 decap_w0
xfeed_8149 1 0 decap_w0
xfeed_8148 1 0 decap_w0
xfeed_8147 1 0 decap_w0
xfeed_8146 1 0 decap_w0
xfeed_8145 1 0 decap_w0
xfeed_8144 1 0 decap_w0
xfeed_8143 1 0 decap_w0
xfeed_8142 1 0 decap_w0
xfeed_8141 1 0 decap_w0
xfeed_8140 1 0 decap_w0
xfeed_7619 1 0 decap_w0
xfeed_7618 1 0 decap_w0
xfeed_7617 1 0 decap_w0
xfeed_7616 1 0 decap_w0
xfeed_7615 1 0 decap_w0
xfeed_7614 1 0 decap_w0
xfeed_7613 1 0 decap_w0
xfeed_7612 1 0 decap_w0
xfeed_7611 1 0 decap_w0
xfeed_7610 1 0 decap_w0
xfeed_3309 1 0 decap_w0
xfeed_3308 1 0 decap_w0
xfeed_3307 1 0 decap_w0
xfeed_3306 1 0 decap_w0
xfeed_3305 1 0 decap_w0
xfeed_3304 1 0 decap_w0
xfeed_3303 1 0 decap_w0
xfeed_3302 1 0 decap_w0
xfeed_3301 1 0 decap_w0
xfeed_3300 1 0 decap_w0
xfeed_2699 1 0 decap_w0
xfeed_2698 1 0 decap_w0
xfeed_2697 1 0 decap_w0
xfeed_2696 1 0 decap_w0
xfeed_2695 1 0 decap_w0
xfeed_2694 1 0 decap_w0
xfeed_2693 1 0 decap_w0
xfeed_2692 1 0 decap_w0
xfeed_2691 1 0 decap_w0
xfeed_2690 1 0 decap_w0
xfeed_28979 1 0 decap_w0
xfeed_28978 1 0 decap_w0
xfeed_28977 1 0 decap_w0
xfeed_28976 1 0 decap_w0
xfeed_28975 1 0 decap_w0
xfeed_28974 1 0 decap_w0
xfeed_28973 1 0 decap_w0
xfeed_28972 1 0 decap_w0
xfeed_28971 1 0 decap_w0
xfeed_28970 1 0 decap_w0
xfeed_25199 1 0 decap_w0
xfeed_25198 1 0 decap_w0
xfeed_25197 1 0 decap_w0
xfeed_25196 1 0 decap_w0
xfeed_25195 1 0 decap_w0
xfeed_25194 1 0 decap_w0
xfeed_24669 1 0 decap_w0
xfeed_24668 1 0 decap_w0
xfeed_24667 1 0 decap_w0
xfeed_24666 1 0 decap_w0
xfeed_24665 1 0 decap_w0
xfeed_24664 1 0 decap_w0
xfeed_24663 1 0 decap_w0
xfeed_24662 1 0 decap_w0
xfeed_24661 1 0 decap_w0
xfeed_24660 1 0 decap_w0
xfeed_20359 1 0 decap_w0
xfeed_20358 1 0 decap_w0
xfeed_20357 1 0 decap_w0
xfeed_20356 1 0 decap_w0
xfeed_20355 1 0 decap_w0
xfeed_19199 1 0 decap_w0
xfeed_19198 1 0 decap_w0
xfeed_19197 1 0 decap_w0
xfeed_19196 1 0 decap_w0
xfeed_19195 1 0 decap_w0
xfeed_19194 1 0 decap_w0
xfeed_19193 1 0 decap_w0
xfeed_19192 1 0 decap_w0
xfeed_19191 1 0 decap_w0
xfeed_19190 1 0 decap_w0
xfeed_18669 1 0 decap_w0
xfeed_18668 1 0 decap_w0
xfeed_18667 1 0 decap_w0
xfeed_18666 1 0 decap_w0
xfeed_18665 1 0 decap_w0
xfeed_18664 1 0 decap_w0
xfeed_18663 1 0 decap_w0
xfeed_18662 1 0 decap_w0
xfeed_18661 1 0 decap_w0
xfeed_18660 1 0 decap_w0
xfeed_14359 1 0 decap_w0
xfeed_14358 1 0 decap_w0
xfeed_14357 1 0 decap_w0
xfeed_14356 1 0 decap_w0
xfeed_14355 1 0 decap_w0
xfeed_14354 1 0 decap_w0
xfeed_14353 1 0 decap_w0
xfeed_14352 1 0 decap_w0
xfeed_14351 1 0 decap_w0
xfeed_14350 1 0 decap_w0
xfeed_13829 1 0 decap_w0
xfeed_13828 1 0 decap_w0
xfeed_13827 1 0 decap_w0
xfeed_13826 1 0 decap_w0
xfeed_13825 1 0 decap_w0
xfeed_13824 1 0 decap_w0
xfeed_13823 1 0 decap_w0
xfeed_13822 1 0 decap_w0
xfeed_13821 1 0 decap_w0
xfeed_13820 1 0 decap_w0
xfeed_10049 1 0 decap_w0
xfeed_10048 1 0 decap_w0
xfeed_10047 1 0 decap_w0
xfeed_10046 1 0 decap_w0
xfeed_10045 1 0 decap_w0
xfeed_10044 1 0 decap_w0
xfeed_10043 1 0 decap_w0
xfeed_10042 1 0 decap_w0
xfeed_10041 1 0 decap_w0
xfeed_10040 1 0 decap_w0
xfeed_679 1 0 decap_w0
xfeed_678 1 0 decap_w0
xfeed_677 1 0 decap_w0
xfeed_676 1 0 decap_w0
xfeed_675 1 0 decap_w0
xfeed_674 1 0 decap_w0
xfeed_673 1 0 decap_w0
xfeed_672 1 0 decap_w0
xfeed_671 1 0 decap_w0
xfeed_670 1 0 decap_w0
xsubckt_22_nexor2_x0 1 0 52 62 125 nexor2_x0
xsubckt_31_nexor2_x0 1 0 54 52 118 nexor2_x0
xfeed_30679 1 0 decap_w0
xfeed_30678 1 0 decap_w0
xfeed_30677 1 0 decap_w0
xfeed_30676 1 0 decap_w0
xfeed_30675 1 0 decap_w0
xfeed_30674 1 0 decap_w0
xfeed_30673 1 0 decap_w0
xfeed_30672 1 0 decap_w0
xfeed_30671 1 0 decap_w0
xfeed_30670 1 0 decap_w0
xfeed_20361 1 0 decap_w0
xfeed_20360 1 0 decap_w0
xfeed_8159 1 0 decap_w0
xfeed_8158 1 0 decap_w0
xfeed_8157 1 0 decap_w0
xfeed_8156 1 0 decap_w0
xfeed_8155 1 0 decap_w0
xfeed_8154 1 0 decap_w0
xfeed_8153 1 0 decap_w0
xfeed_8152 1 0 decap_w0
xfeed_8151 1 0 decap_w0
xfeed_8150 1 0 decap_w0
xfeed_7629 1 0 decap_w0
xfeed_7628 1 0 decap_w0
xfeed_7627 1 0 decap_w0
xfeed_7626 1 0 decap_w0
xfeed_7625 1 0 decap_w0
xfeed_7624 1 0 decap_w0
xfeed_7623 1 0 decap_w0
xfeed_7622 1 0 decap_w0
xfeed_7621 1 0 decap_w0
xfeed_7620 1 0 decap_w0
xfeed_3319 1 0 decap_w0
xfeed_3318 1 0 decap_w0
xfeed_3317 1 0 decap_w0
xfeed_3316 1 0 decap_w0
xfeed_3315 1 0 decap_w0
xfeed_3314 1 0 decap_w0
xfeed_3313 1 0 decap_w0
xfeed_3312 1 0 decap_w0
xfeed_3311 1 0 decap_w0
xfeed_3310 1 0 decap_w0
xfeed_28989 1 0 decap_w0
xfeed_28988 1 0 decap_w0
xfeed_28987 1 0 decap_w0
xfeed_28986 1 0 decap_w0
xfeed_28985 1 0 decap_w0
xfeed_28984 1 0 decap_w0
xfeed_28983 1 0 decap_w0
xfeed_28982 1 0 decap_w0
xfeed_28981 1 0 decap_w0
xfeed_28980 1 0 decap_w0
xfeed_24679 1 0 decap_w0
xfeed_24678 1 0 decap_w0
xfeed_24677 1 0 decap_w0
xfeed_24676 1 0 decap_w0
xfeed_24675 1 0 decap_w0
xfeed_24674 1 0 decap_w0
xfeed_24673 1 0 decap_w0
xfeed_24672 1 0 decap_w0
xfeed_24671 1 0 decap_w0
xfeed_24670 1 0 decap_w0
xfeed_20369 1 0 decap_w0
xfeed_20368 1 0 decap_w0
xfeed_20367 1 0 decap_w0
xfeed_20366 1 0 decap_w0
xfeed_20365 1 0 decap_w0
xfeed_20364 1 0 decap_w0
xfeed_20363 1 0 decap_w0
xfeed_20362 1 0 decap_w0
xfeed_18679 1 0 decap_w0
xfeed_18678 1 0 decap_w0
xfeed_18677 1 0 decap_w0
xfeed_18676 1 0 decap_w0
xfeed_18675 1 0 decap_w0
xfeed_18674 1 0 decap_w0
xfeed_18673 1 0 decap_w0
xfeed_18672 1 0 decap_w0
xfeed_18671 1 0 decap_w0
xfeed_18670 1 0 decap_w0
xfeed_14369 1 0 decap_w0
xfeed_14368 1 0 decap_w0
xfeed_14367 1 0 decap_w0
xfeed_14366 1 0 decap_w0
xfeed_14365 1 0 decap_w0
xfeed_14364 1 0 decap_w0
xfeed_14363 1 0 decap_w0
xfeed_14362 1 0 decap_w0
xfeed_14361 1 0 decap_w0
xfeed_14360 1 0 decap_w0
xfeed_13839 1 0 decap_w0
xfeed_13838 1 0 decap_w0
xfeed_13837 1 0 decap_w0
xfeed_13836 1 0 decap_w0
xfeed_13835 1 0 decap_w0
xfeed_13834 1 0 decap_w0
xfeed_13833 1 0 decap_w0
xfeed_13832 1 0 decap_w0
xfeed_13831 1 0 decap_w0
xfeed_13830 1 0 decap_w0
xfeed_10059 1 0 decap_w0
xfeed_10058 1 0 decap_w0
xfeed_10057 1 0 decap_w0
xfeed_10056 1 0 decap_w0
xfeed_10055 1 0 decap_w0
xfeed_10054 1 0 decap_w0
xfeed_10053 1 0 decap_w0
xfeed_10052 1 0 decap_w0
xfeed_10051 1 0 decap_w0
xfeed_10050 1 0 decap_w0
xfeed_689 1 0 decap_w0
xfeed_688 1 0 decap_w0
xfeed_687 1 0 decap_w0
xfeed_686 1 0 decap_w0
xfeed_685 1 0 decap_w0
xfeed_684 1 0 decap_w0
xfeed_683 1 0 decap_w0
xfeed_682 1 0 decap_w0
xfeed_681 1 0 decap_w0
xfeed_680 1 0 decap_w0
xfeed_30689 1 0 decap_w0
xfeed_30688 1 0 decap_w0
xfeed_30687 1 0 decap_w0
xfeed_30686 1 0 decap_w0
xfeed_30685 1 0 decap_w0
xfeed_30684 1 0 decap_w0
xfeed_30683 1 0 decap_w0
xfeed_30682 1 0 decap_w0
xfeed_30681 1 0 decap_w0
xfeed_30680 1 0 decap_w0
xfeed_29605 1 0 decap_w0
xfeed_29604 1 0 decap_w0
xfeed_29603 1 0 decap_w0
xfeed_29602 1 0 decap_w0
xfeed_29601 1 0 decap_w0
xfeed_29600 1 0 decap_w0
xfeed_8169 1 0 decap_w0
xfeed_8168 1 0 decap_w0
xfeed_8167 1 0 decap_w0
xfeed_8166 1 0 decap_w0
xfeed_8165 1 0 decap_w0
xfeed_8164 1 0 decap_w0
xfeed_8163 1 0 decap_w0
xfeed_8162 1 0 decap_w0
xfeed_8161 1 0 decap_w0
xfeed_8160 1 0 decap_w0
xfeed_7639 1 0 decap_w0
xfeed_7638 1 0 decap_w0
xfeed_7637 1 0 decap_w0
xfeed_7636 1 0 decap_w0
xfeed_7635 1 0 decap_w0
xfeed_7634 1 0 decap_w0
xfeed_7633 1 0 decap_w0
xfeed_7632 1 0 decap_w0
xfeed_7631 1 0 decap_w0
xfeed_7630 1 0 decap_w0
xfeed_3329 1 0 decap_w0
xfeed_3328 1 0 decap_w0
xfeed_3327 1 0 decap_w0
xfeed_3326 1 0 decap_w0
xfeed_3325 1 0 decap_w0
xfeed_3324 1 0 decap_w0
xfeed_3323 1 0 decap_w0
xfeed_3322 1 0 decap_w0
xfeed_3321 1 0 decap_w0
xfeed_3320 1 0 decap_w0
xsubckt_91_nexor2_x0 1 0 146 182 13 nexor2_x0
xfeed_29609 1 0 decap_w0
xfeed_29608 1 0 decap_w0
xfeed_29607 1 0 decap_w0
xfeed_29606 1 0 decap_w0
xfeed_28999 1 0 decap_w0
xfeed_28998 1 0 decap_w0
xfeed_28997 1 0 decap_w0
xfeed_28996 1 0 decap_w0
xfeed_28995 1 0 decap_w0
xfeed_28994 1 0 decap_w0
xfeed_28993 1 0 decap_w0
xfeed_28992 1 0 decap_w0
xfeed_28991 1 0 decap_w0
xfeed_28990 1 0 decap_w0
xfeed_24689 1 0 decap_w0
xfeed_24688 1 0 decap_w0
xfeed_24687 1 0 decap_w0
xfeed_24686 1 0 decap_w0
xfeed_24685 1 0 decap_w0
xfeed_24684 1 0 decap_w0
xfeed_24683 1 0 decap_w0
xfeed_24682 1 0 decap_w0
xfeed_24681 1 0 decap_w0
xfeed_24680 1 0 decap_w0
xfeed_20379 1 0 decap_w0
xfeed_20378 1 0 decap_w0
xfeed_20377 1 0 decap_w0
xfeed_20376 1 0 decap_w0
xfeed_20375 1 0 decap_w0
xfeed_20374 1 0 decap_w0
xfeed_20373 1 0 decap_w0
xfeed_20372 1 0 decap_w0
xfeed_20371 1 0 decap_w0
xfeed_20370 1 0 decap_w0
xfeed_18689 1 0 decap_w0
xfeed_18688 1 0 decap_w0
xfeed_18687 1 0 decap_w0
xfeed_18686 1 0 decap_w0
xfeed_18685 1 0 decap_w0
xfeed_18684 1 0 decap_w0
xfeed_18683 1 0 decap_w0
xfeed_18682 1 0 decap_w0
xfeed_18681 1 0 decap_w0
xfeed_18680 1 0 decap_w0
xfeed_14379 1 0 decap_w0
xfeed_14378 1 0 decap_w0
xfeed_14377 1 0 decap_w0
xfeed_14376 1 0 decap_w0
xfeed_14375 1 0 decap_w0
xfeed_14374 1 0 decap_w0
xfeed_14373 1 0 decap_w0
xfeed_14372 1 0 decap_w0
xfeed_14371 1 0 decap_w0
xfeed_14370 1 0 decap_w0
xfeed_13849 1 0 decap_w0
xfeed_13848 1 0 decap_w0
xfeed_13847 1 0 decap_w0
xfeed_13846 1 0 decap_w0
xfeed_13845 1 0 decap_w0
xfeed_13844 1 0 decap_w0
xfeed_13843 1 0 decap_w0
xfeed_13842 1 0 decap_w0
xfeed_13841 1 0 decap_w0
xfeed_13840 1 0 decap_w0
xfeed_10069 1 0 decap_w0
xfeed_10068 1 0 decap_w0
xfeed_10067 1 0 decap_w0
xfeed_10066 1 0 decap_w0
xfeed_10065 1 0 decap_w0
xfeed_10064 1 0 decap_w0
xfeed_10063 1 0 decap_w0
xfeed_10062 1 0 decap_w0
xfeed_10061 1 0 decap_w0
xfeed_10060 1 0 decap_w0
xfeed_699 1 0 decap_w0
xfeed_698 1 0 decap_w0
xfeed_697 1 0 decap_w0
xfeed_696 1 0 decap_w0
xfeed_695 1 0 decap_w0
xfeed_694 1 0 decap_w0
xfeed_693 1 0 decap_w0
xfeed_692 1 0 decap_w0
xfeed_691 1 0 decap_w0
xfeed_690 1 0 decap_w0
xsubckt_82_nexor2_x0 1 0 153 155 152 nexor2_x0
xfeed_31309 1 0 decap_w0
xfeed_31308 1 0 decap_w0
xfeed_31307 1 0 decap_w0
xfeed_31306 1 0 decap_w0
xfeed_31305 1 0 decap_w0
xfeed_31304 1 0 decap_w0
xfeed_31303 1 0 decap_w0
xfeed_31302 1 0 decap_w0
xfeed_31301 1 0 decap_w0
xfeed_31300 1 0 decap_w0
xfeed_30699 1 0 decap_w0
xfeed_30698 1 0 decap_w0
xfeed_30697 1 0 decap_w0
xfeed_30696 1 0 decap_w0
xfeed_30695 1 0 decap_w0
xfeed_30694 1 0 decap_w0
xfeed_30693 1 0 decap_w0
xfeed_30692 1 0 decap_w0
xfeed_30691 1 0 decap_w0
xfeed_30690 1 0 decap_w0
xfeed_29612 1 0 decap_w0
xfeed_29611 1 0 decap_w0
xfeed_29610 1 0 decap_w0
xfeed_25309 1 0 decap_w0
xfeed_25308 1 0 decap_w0
xfeed_25307 1 0 decap_w0
xfeed_25306 1 0 decap_w0
xfeed_25305 1 0 decap_w0
xfeed_25304 1 0 decap_w0
xfeed_25303 1 0 decap_w0
xfeed_25302 1 0 decap_w0
xfeed_25301 1 0 decap_w0
xfeed_25300 1 0 decap_w0
xfeed_8179 1 0 decap_w0
xfeed_8178 1 0 decap_w0
xfeed_8177 1 0 decap_w0
xfeed_8176 1 0 decap_w0
xfeed_8175 1 0 decap_w0
xfeed_8174 1 0 decap_w0
xfeed_8173 1 0 decap_w0
xfeed_8172 1 0 decap_w0
xfeed_8171 1 0 decap_w0
xfeed_8170 1 0 decap_w0
xfeed_7649 1 0 decap_w0
xfeed_7648 1 0 decap_w0
xfeed_7647 1 0 decap_w0
xfeed_7646 1 0 decap_w0
xfeed_7645 1 0 decap_w0
xfeed_7644 1 0 decap_w0
xfeed_7643 1 0 decap_w0
xfeed_7642 1 0 decap_w0
xfeed_7641 1 0 decap_w0
xfeed_7640 1 0 decap_w0
xfeed_3339 1 0 decap_w0
xfeed_3338 1 0 decap_w0
xfeed_3337 1 0 decap_w0
xfeed_3336 1 0 decap_w0
xfeed_3335 1 0 decap_w0
xfeed_3334 1 0 decap_w0
xfeed_3333 1 0 decap_w0
xfeed_3332 1 0 decap_w0
xfeed_3331 1 0 decap_w0
xfeed_3330 1 0 decap_w0
xfeed_2809 1 0 decap_w0
xfeed_2808 1 0 decap_w0
xfeed_2807 1 0 decap_w0
xfeed_2806 1 0 decap_w0
xfeed_2805 1 0 decap_w0
xfeed_2804 1 0 decap_w0
xfeed_2803 1 0 decap_w0
xfeed_2802 1 0 decap_w0
xfeed_2801 1 0 decap_w0
xfeed_2800 1 0 decap_w0
xsubckt_73_nexor2_x0 1 0 53 41 159 nexor2_x0
xsubckt_64_nexor2_x0 1 0 167 29 28 nexor2_x0
xfeed_29619 1 0 decap_w0
xfeed_29618 1 0 decap_w0
xfeed_29617 1 0 decap_w0
xfeed_29616 1 0 decap_w0
xfeed_29615 1 0 decap_w0
xfeed_29614 1 0 decap_w0
xfeed_29613 1 0 decap_w0
xfeed_24699 1 0 decap_w0
xfeed_24698 1 0 decap_w0
xfeed_24697 1 0 decap_w0
xfeed_24696 1 0 decap_w0
xfeed_24695 1 0 decap_w0
xfeed_24694 1 0 decap_w0
xfeed_24693 1 0 decap_w0
xfeed_24692 1 0 decap_w0
xfeed_24691 1 0 decap_w0
xfeed_24690 1 0 decap_w0
xfeed_20389 1 0 decap_w0
xfeed_20388 1 0 decap_w0
xfeed_20387 1 0 decap_w0
xfeed_20386 1 0 decap_w0
xfeed_20385 1 0 decap_w0
xfeed_20384 1 0 tie
xfeed_20383 1 0 decap_w0
xfeed_20382 1 0 decap_w0
xfeed_20381 1 0 decap_w0
xfeed_20380 1 0 decap_w0
xfeed_19309 1 0 decap_w0
xfeed_19308 1 0 decap_w0
xfeed_19307 1 0 decap_w0
xfeed_19306 1 0 decap_w0
xfeed_19305 1 0 decap_w0
xfeed_19304 1 0 decap_w0
xfeed_19303 1 0 decap_w0
xfeed_19302 1 0 decap_w0
xfeed_19301 1 0 decap_w0
xfeed_19300 1 0 decap_w0
xfeed_18699 1 0 decap_w0
xfeed_18698 1 0 decap_w0
xfeed_18697 1 0 decap_w0
xfeed_18696 1 0 decap_w0
xfeed_18695 1 0 decap_w0
xfeed_18694 1 0 decap_w0
xfeed_18693 1 0 decap_w0
xfeed_18692 1 0 decap_w0
xfeed_18691 1 0 decap_w0
xfeed_18690 1 0 decap_w0
xfeed_14389 1 0 decap_w0
xfeed_14388 1 0 decap_w0
xfeed_14387 1 0 decap_w0
xfeed_14386 1 0 decap_w0
xfeed_14385 1 0 decap_w0
xfeed_14384 1 0 decap_w0
xfeed_14383 1 0 decap_w0
xfeed_14382 1 0 decap_w0
xfeed_14381 1 0 decap_w0
xfeed_14380 1 0 decap_w0
xfeed_13859 1 0 decap_w0
xfeed_13858 1 0 decap_w0
xfeed_13857 1 0 decap_w0
xfeed_13856 1 0 decap_w0
xfeed_13855 1 0 decap_w0
xfeed_13854 1 0 decap_w0
xfeed_13853 1 0 decap_w0
xfeed_13852 1 0 decap_w0
xfeed_13851 1 0 decap_w0
xfeed_13850 1 0 decap_w0
xfeed_10079 1 0 decap_w0
xfeed_10078 1 0 decap_w0
xfeed_10077 1 0 decap_w0
xfeed_10076 1 0 decap_w0
xfeed_10075 1 0 decap_w0
xfeed_10074 1 0 tie
xfeed_10073 1 0 decap_w0
xfeed_10072 1 0 decap_w0
xfeed_10071 1 0 decap_w0
xfeed_10070 1 0 decap_w0
xfeed_31319 1 0 decap_w0
xfeed_31318 1 0 decap_w0
xfeed_31317 1 0 decap_w0
xfeed_31316 1 0 decap_w0
xfeed_31315 1 0 decap_w0
xfeed_31314 1 0 decap_w0
xfeed_31313 1 0 decap_w0
xfeed_31312 1 0 decap_w0
xfeed_31311 1 0 decap_w0
xfeed_31310 1 0 decap_w0
xfeed_25319 1 0 decap_w0
xfeed_25318 1 0 decap_w0
xfeed_25317 1 0 decap_w0
xfeed_25316 1 0 tie
xfeed_25315 1 0 decap_w0
xfeed_25314 1 0 decap_w0
xfeed_25313 1 0 decap_w0
xfeed_25312 1 0 decap_w0
xfeed_25311 1 0 decap_w0
xfeed_25310 1 0 decap_w0
xfeed_21009 1 0 decap_w0
xfeed_21008 1 0 decap_w0
xfeed_21007 1 0 decap_w0
xfeed_21006 1 0 decap_w0
xfeed_21005 1 0 decap_w0
xfeed_21004 1 0 decap_w0
xfeed_21003 1 0 decap_w0
xfeed_21002 1 0 decap_w0
xfeed_21001 1 0 decap_w0
xfeed_21000 1 0 decap_w0
xfeed_8189 1 0 decap_w0
xfeed_8188 1 0 decap_w0
xfeed_8187 1 0 decap_w0
xfeed_8186 1 0 decap_w0
xfeed_8185 1 0 decap_w0
xfeed_8184 1 0 decap_w0
xfeed_8183 1 0 decap_w0
xfeed_8182 1 0 decap_w0
xfeed_8181 1 0 decap_w0
xfeed_8180 1 0 decap_w0
xfeed_7659 1 0 decap_w0
xfeed_7658 1 0 decap_w0
xfeed_7657 1 0 decap_w0
xfeed_7656 1 0 decap_w0
xfeed_7655 1 0 decap_w0
xfeed_7654 1 0 decap_w0
xfeed_7653 1 0 decap_w0
xfeed_7652 1 0 decap_w0
xfeed_7651 1 0 decap_w0
xfeed_7650 1 0 decap_w0
xfeed_3349 1 0 decap_w0
xfeed_3348 1 0 decap_w0
xfeed_3347 1 0 decap_w0
xfeed_3346 1 0 decap_w0
xfeed_3345 1 0 decap_w0
xfeed_3344 1 0 decap_w0
xfeed_3343 1 0 decap_w0
xfeed_3342 1 0 decap_w0
xfeed_3341 1 0 decap_w0
xfeed_3340 1 0 decap_w0
xfeed_2819 1 0 decap_w0
xfeed_2818 1 0 decap_w0
xfeed_2817 1 0 decap_w0
xfeed_2816 1 0 decap_w0
xfeed_2815 1 0 decap_w0
xfeed_2814 1 0 decap_w0
xfeed_2813 1 0 decap_w0
xfeed_2812 1 0 decap_w0
xfeed_2811 1 0 decap_w0
xfeed_2810 1 0 decap_w0
xfeed_29629 1 0 decap_w0
xfeed_29628 1 0 decap_w0
xfeed_29627 1 0 decap_w0
xfeed_29626 1 0 decap_w0
xfeed_29625 1 0 decap_w0
xfeed_29624 1 0 decap_w0
xfeed_29623 1 0 decap_w0
xfeed_29622 1 0 decap_w0
xfeed_29621 1 0 decap_w0
xfeed_29620 1 0 decap_w0
xfeed_20399 1 0 decap_w0
xfeed_20398 1 0 decap_w0
xfeed_20397 1 0 decap_w0
xfeed_20396 1 0 decap_w0
xfeed_20395 1 0 decap_w0
xfeed_20394 1 0 decap_w0
xfeed_20393 1 0 decap_w0
xfeed_20392 1 0 decap_w0
xfeed_20391 1 0 decap_w0
xfeed_20390 1 0 decap_w0
xfeed_19319 1 0 decap_w0
xfeed_19318 1 0 decap_w0
xfeed_19317 1 0 decap_w0
xfeed_19316 1 0 decap_w0
xfeed_19315 1 0 decap_w0
xfeed_19314 1 0 decap_w0
xfeed_19313 1 0 decap_w0
xfeed_19312 1 0 decap_w0
xfeed_19311 1 0 decap_w0
xfeed_19310 1 0 decap_w0
xfeed_15009 1 0 decap_w0
xfeed_15008 1 0 decap_w0
xfeed_15007 1 0 decap_w0
xfeed_15006 1 0 decap_w0
xfeed_15005 1 0 decap_w0
xfeed_15004 1 0 decap_w0
xfeed_15003 1 0 decap_w0
xfeed_15002 1 0 decap_w0
xfeed_15001 1 0 decap_w0
xfeed_15000 1 0 decap_w0
xfeed_14399 1 0 decap_w0
xfeed_14398 1 0 decap_w0
xfeed_14397 1 0 decap_w0
xfeed_14396 1 0 decap_w0
xfeed_14395 1 0 decap_w0
xfeed_14394 1 0 decap_w0
xfeed_14393 1 0 decap_w0
xfeed_14392 1 0 decap_w0
xfeed_14391 1 0 decap_w0
xfeed_14390 1 0 decap_w0
xfeed_13869 1 0 decap_w0
xfeed_13868 1 0 decap_w0
xfeed_13867 1 0 decap_w0
xfeed_13866 1 0 decap_w0
xfeed_13865 1 0 decap_w0
xfeed_13864 1 0 decap_w0
xfeed_13863 1 0 decap_w0
xfeed_13862 1 0 decap_w0
xfeed_13861 1 0 decap_w0
xfeed_13860 1 0 decap_w0
xfeed_10089 1 0 decap_w0
xfeed_10088 1 0 decap_w0
xfeed_10087 1 0 decap_w0
xfeed_10086 1 0 decap_w0
xfeed_10085 1 0 decap_w0
xfeed_10084 1 0 decap_w0
xfeed_10083 1 0 decap_w0
xfeed_10082 1 0 decap_w0
xfeed_10081 1 0 decap_w0
xfeed_10080 1 0 decap_w0
xsubckt_21_inv_x0 1 0 126 5 inv_x0
xsubckt_28_nexor2_x0 1 0 122 124 120 nexor2_x0
xfeed_31329 1 0 decap_w0
xfeed_31328 1 0 decap_w0
xfeed_31327 1 0 decap_w0
xfeed_31326 1 0 decap_w0
xfeed_31325 1 0 decap_w0
xfeed_31324 1 0 decap_w0
xfeed_31323 1 0 decap_w0
xfeed_31322 1 0 decap_w0
xfeed_31321 1 0 decap_w0
xfeed_31320 1 0 decap_w0
xfeed_25326 1 0 decap_w0
xfeed_25325 1 0 decap_w0
xfeed_25324 1 0 decap_w0
xfeed_25323 1 0 decap_w0
xfeed_25322 1 0 decap_w0
xfeed_25321 1 0 decap_w0
xfeed_25320 1 0 decap_w0
xfeed_21019 1 0 decap_w0
xfeed_21018 1 0 decap_w0
xfeed_21017 1 0 decap_w0
xfeed_21016 1 0 decap_w0
xfeed_21015 1 0 decap_w0
xfeed_21014 1 0 decap_w0
xfeed_21013 1 0 decap_w0
xfeed_21012 1 0 decap_w0
xfeed_21011 1 0 decap_w0
xfeed_21010 1 0 decap_w0
xfeed_8199 1 0 decap_w0
xfeed_8198 1 0 decap_w0
xfeed_8197 1 0 decap_w0
xfeed_8196 1 0 decap_w0
xfeed_8195 1 0 decap_w0
xfeed_8194 1 0 decap_w0
xfeed_8193 1 0 decap_w0
xfeed_8192 1 0 decap_w0
xfeed_8191 1 0 decap_w0
xfeed_8190 1 0 decap_w0
xfeed_7669 1 0 decap_w0
xfeed_7668 1 0 decap_w0
xfeed_7667 1 0 decap_w0
xfeed_7666 1 0 decap_w0
xfeed_7665 1 0 decap_w0
xfeed_7664 1 0 decap_w0
xfeed_7663 1 0 decap_w0
xfeed_7662 1 0 decap_w0
xfeed_7661 1 0 decap_w0
xfeed_7660 1 0 decap_w0
xfeed_3359 1 0 decap_w0
xfeed_3358 1 0 decap_w0
xfeed_3357 1 0 decap_w0
xfeed_3356 1 0 decap_w0
xfeed_3355 1 0 decap_w0
xfeed_3354 1 0 decap_w0
xfeed_3353 1 0 decap_w0
xfeed_3352 1 0 decap_w0
xfeed_3351 1 0 decap_w0
xfeed_3350 1 0 decap_w0
xfeed_2829 1 0 decap_w0
xfeed_2828 1 0 decap_w0
xfeed_2827 1 0 decap_w0
xfeed_2826 1 0 decap_w0
xfeed_2825 1 0 decap_w0
xfeed_2824 1 0 decap_w0
xfeed_2823 1 0 decap_w0
xfeed_2822 1 0 decap_w0
xfeed_2821 1 0 decap_w0
xfeed_2820 1 0 decap_w0
xfeed_800 1 0 decap_w0
xsubckt_25_inv_x0 1 0 123 31 inv_x0
xfeed_29639 1 0 decap_w0
xfeed_29638 1 0 decap_w0
xfeed_29637 1 0 decap_w0
xfeed_29636 1 0 decap_w0
xfeed_29635 1 0 decap_w0
xfeed_29634 1 0 decap_w0
xfeed_29633 1 0 decap_w0
xfeed_29632 1 0 decap_w0
xfeed_29631 1 0 decap_w0
xfeed_29630 1 0 decap_w0
xfeed_25329 1 0 decap_w0
xfeed_25328 1 0 decap_w0
xfeed_25327 1 0 decap_w0
xfeed_19329 1 0 decap_w0
xfeed_19328 1 0 decap_w0
xfeed_19327 1 0 decap_w0
xfeed_19326 1 0 decap_w0
xfeed_19325 1 0 decap_w0
xfeed_19324 1 0 decap_w0
xfeed_19323 1 0 decap_w0
xfeed_19322 1 0 decap_w0
xfeed_19321 1 0 decap_w0
xfeed_19320 1 0 decap_w0
xfeed_15019 1 0 decap_w0
xfeed_15018 1 0 decap_w0
xfeed_15017 1 0 decap_w0
xfeed_15016 1 0 decap_w0
xfeed_15015 1 0 decap_w0
xfeed_15014 1 0 decap_w0
xfeed_15013 1 0 decap_w0
xfeed_15012 1 0 decap_w0
xfeed_15011 1 0 decap_w0
xfeed_15010 1 0 decap_w0
xfeed_13879 1 0 decap_w0
xfeed_13878 1 0 decap_w0
xfeed_13877 1 0 decap_w0
xfeed_13876 1 0 decap_w0
xfeed_13875 1 0 decap_w0
xfeed_13874 1 0 decap_w0
xfeed_13873 1 0 decap_w0
xfeed_13872 1 0 decap_w0
xfeed_13871 1 0 decap_w0
xfeed_13870 1 0 decap_w0
xfeed_10099 1 0 decap_w0
xfeed_10098 1 0 decap_w0
xfeed_10097 1 0 decap_w0
xfeed_10096 1 0 decap_w0
xfeed_10095 1 0 decap_w0
xfeed_10094 1 0 decap_w0
xfeed_10093 1 0 decap_w0
xfeed_10092 1 0 decap_w0
xfeed_10091 1 0 decap_w0
xfeed_10090 1 0 decap_w0
xfeed_809 1 0 decap_w0
xfeed_808 1 0 decap_w0
xfeed_807 1 0 decap_w0
xfeed_806 1 0 decap_w0
xfeed_805 1 0 decap_w0
xfeed_804 1 0 decap_w0
xfeed_803 1 0 decap_w0
xfeed_802 1 0 decap_w0
xfeed_801 1 0 decap_w0
xfeed_31339 1 0 decap_w0
xfeed_31338 1 0 decap_w0
xfeed_31337 1 0 decap_w0
xfeed_31336 1 0 decap_w0
xfeed_31335 1 0 decap_w0
xfeed_31334 1 0 decap_w0
xfeed_31333 1 0 decap_w0
xfeed_31332 1 0 decap_w0
xfeed_31331 1 0 decap_w0
xfeed_31330 1 0 decap_w0
xfeed_30809 1 0 decap_w0
xfeed_30808 1 0 decap_w0
xfeed_30807 1 0 decap_w0
xfeed_30806 1 0 decap_w0
xfeed_30805 1 0 decap_w0
xfeed_30804 1 0 decap_w0
xfeed_30803 1 0 decap_w0
xfeed_30802 1 0 decap_w0
xfeed_30801 1 0 decap_w0
xfeed_30800 1 0 decap_w0
xfeed_25333 1 0 decap_w0
xfeed_25332 1 0 decap_w0
xfeed_25331 1 0 decap_w0
xfeed_25330 1 0 decap_w0
xfeed_21029 1 0 decap_w0
xfeed_21028 1 0 decap_w0
xfeed_21027 1 0 decap_w0
xfeed_21026 1 0 decap_w0
xfeed_21025 1 0 decap_w0
xfeed_21024 1 0 decap_w0
xfeed_21023 1 0 decap_w0
xfeed_21022 1 0 decap_w0
xfeed_21021 1 0 decap_w0
xfeed_21020 1 0 decap_w0
xfeed_7679 1 0 decap_w0
xfeed_7678 1 0 decap_w0
xfeed_7677 1 0 decap_w0
xfeed_7676 1 0 decap_w0
xfeed_7675 1 0 decap_w0
xfeed_7674 1 0 decap_w0
xfeed_7673 1 0 decap_w0
xfeed_7672 1 0 decap_w0
xfeed_7671 1 0 decap_w0
xfeed_7670 1 0 decap_w0
xfeed_3369 1 0 decap_w0
xfeed_3368 1 0 decap_w0
xfeed_3367 1 0 decap_w0
xfeed_3366 1 0 decap_w0
xfeed_3365 1 0 decap_w0
xfeed_3364 1 0 decap_w0
xfeed_3363 1 0 decap_w0
xfeed_3362 1 0 decap_w0
xfeed_3361 1 0 decap_w0
xfeed_3360 1 0 decap_w0
xfeed_2839 1 0 decap_w0
xfeed_2838 1 0 decap_w0
xfeed_2837 1 0 decap_w0
xfeed_2836 1 0 decap_w0
xfeed_2835 1 0 decap_w0
xfeed_2834 1 0 decap_w0
xfeed_2833 1 0 decap_w0
xfeed_2832 1 0 decap_w0
xfeed_2831 1 0 decap_w0
xfeed_2830 1 0 decap_w0
xsubckt_97_nexor2_x0 1 0 142 164 141 nexor2_x0
xfeed_29649 1 0 decap_w0
xfeed_29648 1 0 decap_w0
xfeed_29647 1 0 decap_w0
xfeed_29646 1 0 decap_w0
xfeed_29645 1 0 decap_w0
xfeed_29644 1 0 decap_w0
xfeed_29643 1 0 decap_w0
xfeed_29642 1 0 decap_w0
xfeed_29641 1 0 decap_w0
xfeed_29640 1 0 decap_w0
xfeed_25339 1 0 decap_w0
xfeed_25338 1 0 decap_w0
xfeed_25337 1 0 decap_w0
xfeed_25336 1 0 decap_w0
xfeed_25335 1 0 decap_w0
xfeed_25334 1 0 decap_w0
xfeed_24809 1 0 decap_w0
xfeed_24808 1 0 decap_w0
xfeed_24807 1 0 decap_w0
xfeed_24806 1 0 decap_w0
xfeed_24805 1 0 decap_w0
xfeed_24804 1 0 decap_w0
xfeed_24803 1 0 decap_w0
xfeed_24802 1 0 decap_w0
xfeed_24801 1 0 decap_w0
xfeed_24800 1 0 decap_w0
xfeed_19339 1 0 decap_w0
xfeed_19338 1 0 decap_w0
xfeed_19337 1 0 decap_w0
xfeed_19336 1 0 decap_w0
xfeed_19335 1 0 decap_w0
xfeed_19334 1 0 decap_w0
xfeed_19333 1 0 decap_w0
xfeed_19332 1 0 decap_w0
xfeed_19331 1 0 decap_w0
xfeed_19330 1 0 decap_w0
xfeed_18809 1 0 decap_w0
xfeed_18808 1 0 decap_w0
xfeed_18807 1 0 decap_w0
xfeed_18806 1 0 decap_w0
xfeed_18805 1 0 decap_w0
xfeed_18804 1 0 decap_w0
xfeed_18803 1 0 decap_w0
xfeed_18802 1 0 decap_w0
xfeed_18801 1 0 decap_w0
xfeed_18800 1 0 decap_w0
xfeed_15029 1 0 decap_w0
xfeed_15028 1 0 decap_w0
xfeed_15027 1 0 decap_w0
xfeed_15026 1 0 decap_w0
xfeed_15025 1 0 decap_w0
xfeed_15024 1 0 decap_w0
xfeed_15023 1 0 decap_w0
xfeed_15022 1 0 decap_w0
xfeed_15021 1 0 decap_w0
xfeed_15020 1 0 decap_w0
xfeed_13889 1 0 decap_w0
xfeed_13888 1 0 decap_w0
xfeed_13887 1 0 decap_w0
xfeed_13886 1 0 decap_w0
xfeed_13885 1 0 decap_w0
xfeed_13884 1 0 decap_w0
xfeed_13883 1 0 decap_w0
xfeed_13882 1 0 decap_w0
xfeed_13881 1 0 decap_w0
xfeed_13880 1 0 decap_w0
xfeed_819 1 0 decap_w0
xfeed_818 1 0 decap_w0
xfeed_817 1 0 decap_w0
xfeed_816 1 0 decap_w0
xfeed_815 1 0 decap_w0
xfeed_814 1 0 decap_w0
xfeed_813 1 0 decap_w0
xfeed_812 1 0 decap_w0
xfeed_811 1 0 decap_w0
xfeed_810 1 0 decap_w0
xsubckt_79_nexor2_x0 1 0 156 131 19 nexor2_x0
xfeed_31349 1 0 decap_w0
xfeed_31348 1 0 decap_w0
xfeed_31347 1 0 decap_w0
xfeed_31346 1 0 decap_w0
xfeed_31345 1 0 decap_w0
xfeed_31344 1 0 decap_w0
xfeed_31343 1 0 decap_w0
xfeed_31342 1 0 decap_w0
xfeed_31341 1 0 decap_w0
xfeed_31340 1 0 decap_w0
xfeed_30819 1 0 decap_w0
xfeed_30818 1 0 decap_w0
xfeed_30817 1 0 decap_w0
xfeed_30816 1 0 decap_w0
xfeed_30815 1 0 decap_w0
xfeed_30814 1 0 decap_w0
xfeed_30813 1 0 decap_w0
xfeed_30812 1 0 decap_w0
xfeed_30811 1 0 decap_w0
xfeed_30810 1 0 decap_w0
xfeed_25340 1 0 decap_w0
xfeed_21039 1 0 decap_w0
xfeed_21038 1 0 decap_w0
xfeed_21037 1 0 decap_w0
xfeed_21036 1 0 decap_w0
xfeed_21035 1 0 decap_w0
xfeed_21034 1 0 decap_w0
xfeed_21033 1 0 decap_w0
xfeed_21032 1 0 decap_w0
xfeed_21031 1 0 decap_w0
xfeed_21030 1 0 decap_w0
xfeed_20501 1 0 decap_w0
xfeed_20500 1 0 decap_w0
xfeed_7689 1 0 decap_w0
xfeed_7688 1 0 decap_w0
xfeed_7687 1 0 decap_w0
xfeed_7686 1 0 decap_w0
xfeed_7685 1 0 decap_w0
xfeed_7684 1 0 decap_w0
xfeed_7683 1 0 decap_w0
xfeed_7682 1 0 decap_w0
xfeed_7681 1 0 decap_w0
xfeed_7680 1 0 decap_w0
xfeed_3379 1 0 decap_w0
xfeed_3378 1 0 decap_w0
xfeed_3377 1 0 decap_w0
xfeed_3376 1 0 decap_w0
xfeed_3375 1 0 decap_w0
xfeed_3374 1 0 decap_w0
xfeed_3373 1 0 decap_w0
xfeed_3372 1 0 decap_w0
xfeed_3371 1 0 tie
xfeed_3370 1 0 decap_w0
xfeed_2849 1 0 decap_w0
xfeed_2848 1 0 decap_w0
xfeed_2847 1 0 decap_w0
xfeed_2846 1 0 decap_w0
xfeed_2845 1 0 decap_w0
xfeed_2844 1 0 decap_w0
xfeed_2843 1 0 decap_w0
xfeed_2842 1 0 decap_w0
xfeed_2841 1 0 decap_w0
xfeed_2840 1 0 decap_w0
xfeed_29659 1 0 decap_w0
xfeed_29658 1 0 decap_w0
xfeed_29657 1 0 decap_w0
xfeed_29656 1 0 decap_w0
xfeed_29655 1 0 decap_w0
xfeed_29654 1 0 decap_w0
xfeed_29653 1 0 decap_w0
xfeed_29652 1 0 decap_w0
xfeed_29651 1 0 decap_w0
xfeed_29650 1 0 decap_w0
xfeed_25349 1 0 decap_w0
xfeed_25348 1 0 decap_w0
xfeed_25347 1 0 decap_w0
xfeed_25346 1 0 decap_w0
xfeed_25345 1 0 decap_w0
xfeed_25344 1 0 decap_w0
xfeed_25343 1 0 decap_w0
xfeed_25342 1 0 decap_w0
xfeed_25341 1 0 decap_w0
xfeed_24819 1 0 decap_w0
xfeed_24818 1 0 decap_w0
xfeed_24817 1 0 decap_w0
xfeed_24816 1 0 decap_w0
xfeed_24815 1 0 decap_w0
xfeed_24814 1 0 decap_w0
xfeed_24813 1 0 decap_w0
xfeed_24812 1 0 decap_w0
xfeed_24811 1 0 decap_w0
xfeed_24810 1 0 decap_w0
xfeed_20509 1 0 decap_w0
xfeed_20508 1 0 decap_w0
xfeed_20507 1 0 decap_w0
xfeed_20506 1 0 decap_w0
xfeed_20505 1 0 decap_w0
xfeed_20504 1 0 decap_w0
xfeed_20503 1 0 decap_w0
xfeed_20502 1 0 decap_w0
xfeed_19349 1 0 decap_w0
xfeed_19348 1 0 decap_w0
xfeed_19347 1 0 decap_w0
xfeed_19346 1 0 decap_w0
xfeed_19345 1 0 decap_w0
xfeed_19344 1 0 decap_w0
xfeed_19343 1 0 decap_w0
xfeed_19342 1 0 decap_w0
xfeed_19341 1 0 decap_w0
xfeed_19340 1 0 decap_w0
xfeed_18819 1 0 decap_w0
xfeed_18818 1 0 decap_w0
xfeed_18817 1 0 decap_w0
xfeed_18816 1 0 decap_w0
xfeed_18815 1 0 decap_w0
xfeed_18814 1 0 decap_w0
xfeed_18813 1 0 decap_w0
xfeed_18812 1 0 decap_w0
xfeed_18811 1 0 decap_w0
xfeed_18810 1 0 decap_w0
xfeed_15039 1 0 decap_w0
xfeed_15038 1 0 decap_w0
xfeed_15037 1 0 decap_w0
xfeed_15036 1 0 decap_w0
xfeed_15035 1 0 decap_w0
xfeed_15034 1 0 decap_w0
xfeed_15033 1 0 decap_w0
xfeed_15032 1 0 decap_w0
xfeed_15031 1 0 decap_w0
xfeed_15030 1 0 decap_w0
xfeed_14509 1 0 decap_w0
xfeed_14508 1 0 decap_w0
xfeed_14507 1 0 decap_w0
xfeed_14506 1 0 decap_w0
xfeed_14505 1 0 decap_w0
xfeed_14504 1 0 decap_w0
xfeed_14503 1 0 decap_w0
xfeed_14502 1 0 decap_w0
xfeed_14501 1 0 decap_w0
xfeed_14500 1 0 decap_w0
xfeed_13899 1 0 decap_w0
xfeed_13898 1 0 decap_w0
xfeed_13897 1 0 decap_w0
xfeed_13896 1 0 decap_w0
xfeed_13895 1 0 decap_w0
xfeed_13894 1 0 decap_w0
xfeed_13893 1 0 decap_w0
xfeed_13892 1 0 decap_w0
xfeed_13891 1 0 decap_w0
xfeed_13890 1 0 decap_w0
xfeed_829 1 0 decap_w0
xfeed_828 1 0 decap_w0
xfeed_827 1 0 decap_w0
xfeed_826 1 0 decap_w0
xfeed_825 1 0 decap_w0
xfeed_824 1 0 decap_w0
xfeed_823 1 0 decap_w0
xfeed_822 1 0 decap_w0
xfeed_821 1 0 decap_w0
xfeed_820 1 0 decap_w0
xfeed_31359 1 0 decap_w0
xfeed_31358 1 0 decap_w0
xfeed_31357 1 0 decap_w0
xfeed_31356 1 0 decap_w0
xfeed_31355 1 0 decap_w0
xfeed_31354 1 0 decap_w0
xfeed_31353 1 0 decap_w0
xfeed_31352 1 0 decap_w0
xfeed_31351 1 0 decap_w0
xfeed_31350 1 0 decap_w0
xfeed_30829 1 0 decap_w0
xfeed_30828 1 0 decap_w0
xfeed_30827 1 0 decap_w0
xfeed_30826 1 0 decap_w0
xfeed_30825 1 0 decap_w0
xfeed_30824 1 0 decap_w0
xfeed_30823 1 0 decap_w0
xfeed_30822 1 0 decap_w0
xfeed_30821 1 0 decap_w0
xfeed_30820 1 0 decap_w0
xfeed_21047 1 0 decap_w0
xfeed_21046 1 0 decap_w0
xfeed_21045 1 0 decap_w0
xfeed_21044 1 0 decap_w0
xfeed_21043 1 0 decap_w0
xfeed_21042 1 0 decap_w0
xfeed_21041 1 0 decap_w0
xfeed_21040 1 0 decap_w0
xfeed_8309 1 0 decap_w0
xfeed_8308 1 0 decap_w0
xfeed_8307 1 0 decap_w0
xfeed_8306 1 0 decap_w0
xfeed_8305 1 0 decap_w0
xfeed_8304 1 0 decap_w0
xfeed_8303 1 0 decap_w0
xfeed_8302 1 0 decap_w0
xfeed_8301 1 0 decap_w0
xfeed_8300 1 0 decap_w0
xfeed_7699 1 0 decap_w0
xfeed_7698 1 0 decap_w0
xfeed_7697 1 0 decap_w0
xfeed_7696 1 0 decap_w0
xfeed_7695 1 0 decap_w0
xfeed_7694 1 0 decap_w0
xfeed_7693 1 0 decap_w0
xfeed_7692 1 0 decap_w0
xfeed_7691 1 0 decap_w0
xfeed_7690 1 0 decap_w0
xfeed_3389 1 0 decap_w0
xfeed_3388 1 0 decap_w0
xfeed_3387 1 0 decap_w0
xfeed_3386 1 0 decap_w0
xfeed_3385 1 0 decap_w0
xfeed_3384 1 0 decap_w0
xfeed_3383 1 0 decap_w0
xfeed_3382 1 0 decap_w0
xfeed_3381 1 0 decap_w0
xfeed_3380 1 0 decap_w0
xfeed_2859 1 0 decap_w0
xfeed_2858 1 0 decap_w0
xfeed_2857 1 0 decap_w0
xfeed_2856 1 0 decap_w0
xfeed_2855 1 0 decap_w0
xfeed_2854 1 0 decap_w0
xfeed_2853 1 0 decap_w0
xfeed_2852 1 0 decap_w0
xfeed_2851 1 0 decap_w0
xfeed_2850 1 0 decap_w0
xfeed_29669 1 0 decap_w0
xfeed_29668 1 0 decap_w0
xfeed_29667 1 0 decap_w0
xfeed_29666 1 0 decap_w0
xfeed_29665 1 0 decap_w0
xfeed_29664 1 0 decap_w0
xfeed_29663 1 0 decap_w0
xfeed_29662 1 0 decap_w0
xfeed_29661 1 0 decap_w0
xfeed_29660 1 0 decap_w0
xfeed_25359 1 0 decap_w0
xfeed_25358 1 0 decap_w0
xfeed_25357 1 0 decap_w0
xfeed_25356 1 0 decap_w0
xfeed_25355 1 0 decap_w0
xfeed_25354 1 0 decap_w0
xfeed_25353 1 0 decap_w0
xfeed_25352 1 0 decap_w0
xfeed_25351 1 0 decap_w0
xfeed_25350 1 0 decap_w0
xfeed_24829 1 0 decap_w0
xfeed_24828 1 0 decap_w0
xfeed_24827 1 0 decap_w0
xfeed_24826 1 0 decap_w0
xfeed_24825 1 0 decap_w0
xfeed_24824 1 0 decap_w0
xfeed_24823 1 0 decap_w0
xfeed_24822 1 0 decap_w0
xfeed_24821 1 0 decap_w0
xfeed_24820 1 0 decap_w0
xfeed_21049 1 0 decap_w0
xfeed_21048 1 0 decap_w0
xfeed_20519 1 0 decap_w0
xfeed_20518 1 0 decap_w0
xfeed_20517 1 0 decap_w0
xfeed_20516 1 0 decap_w0
xfeed_20515 1 0 decap_w0
xfeed_20514 1 0 decap_w0
xfeed_20513 1 0 decap_w0
xfeed_20512 1 0 decap_w0
xfeed_20511 1 0 decap_w0
xfeed_20510 1 0 decap_w0
xfeed_19359 1 0 decap_w0
xfeed_19358 1 0 decap_w0
xfeed_19357 1 0 decap_w0
xfeed_19356 1 0 decap_w0
xfeed_19355 1 0 decap_w0
xfeed_19354 1 0 decap_w0
xfeed_19353 1 0 decap_w0
xfeed_19352 1 0 decap_w0
xfeed_19351 1 0 decap_w0
xfeed_19350 1 0 decap_w0
xfeed_18829 1 0 decap_w0
xfeed_18828 1 0 decap_w0
xfeed_18827 1 0 decap_w0
xfeed_18826 1 0 decap_w0
xfeed_18825 1 0 decap_w0
xfeed_18824 1 0 decap_w0
xfeed_18823 1 0 decap_w0
xfeed_18822 1 0 decap_w0
xfeed_18821 1 0 decap_w0
xfeed_18820 1 0 decap_w0
xfeed_15049 1 0 decap_w0
xfeed_15048 1 0 decap_w0
xfeed_15047 1 0 decap_w0
xfeed_15046 1 0 decap_w0
xfeed_15045 1 0 decap_w0
xfeed_15044 1 0 decap_w0
xfeed_15043 1 0 decap_w0
xfeed_15042 1 0 decap_w0
xfeed_15041 1 0 decap_w0
xfeed_15040 1 0 decap_w0
xfeed_14519 1 0 decap_w0
xfeed_14518 1 0 decap_w0
xfeed_14517 1 0 decap_w0
xfeed_14516 1 0 decap_w0
xfeed_14515 1 0 decap_w0
xfeed_14514 1 0 decap_w0
xfeed_14513 1 0 decap_w0
xfeed_14512 1 0 decap_w0
xfeed_14511 1 0 decap_w0
xfeed_14510 1 0 decap_w0
xfeed_10209 1 0 decap_w0
xfeed_10208 1 0 decap_w0
xfeed_10207 1 0 decap_w0
xfeed_10206 1 0 decap_w0
xfeed_10205 1 0 decap_w0
xfeed_10204 1 0 decap_w0
xfeed_10203 1 0 decap_w0
xfeed_10202 1 0 decap_w0
xfeed_10201 1 0 decap_w0
xfeed_10200 1 0 decap_w0
xfeed_839 1 0 decap_w0
xfeed_838 1 0 decap_w0
xfeed_837 1 0 decap_w0
xfeed_836 1 0 decap_w0
xfeed_835 1 0 decap_w0
xfeed_834 1 0 decap_w0
xfeed_833 1 0 decap_w0
xfeed_832 1 0 decap_w0
xfeed_831 1 0 decap_w0
xfeed_830 1 0 decap_w0
xsubckt_66_xor2_x0 1 0 35 57 164 xor2_x0
xfeed_31369 1 0 decap_w0
xfeed_31368 1 0 decap_w0
xfeed_31367 1 0 decap_w0
xfeed_31366 1 0 decap_w0
xfeed_31365 1 0 decap_w0
xfeed_31364 1 0 decap_w0
xfeed_31363 1 0 decap_w0
xfeed_31362 1 0 decap_w0
xfeed_31361 1 0 decap_w0
xfeed_31360 1 0 decap_w0
xfeed_30839 1 0 decap_w0
xfeed_30838 1 0 decap_w0
xfeed_30837 1 0 decap_w0
xfeed_30836 1 0 decap_w0
xfeed_30835 1 0 decap_w0
xfeed_30834 1 0 decap_w0
xfeed_30833 1 0 decap_w0
xfeed_30832 1 0 decap_w0
xfeed_30831 1 0 decap_w0
xfeed_30830 1 0 decap_w0
xfeed_21054 1 0 decap_w0
xfeed_21053 1 0 decap_w0
xfeed_21052 1 0 decap_w0
xfeed_21051 1 0 decap_w0
xfeed_21050 1 0 decap_w0
xfeed_8319 1 0 decap_w0
xfeed_8318 1 0 decap_w0
xfeed_8317 1 0 decap_w0
xfeed_8316 1 0 decap_w0
xfeed_8315 1 0 decap_w0
xfeed_8314 1 0 decap_w0
xfeed_8313 1 0 decap_w0
xfeed_8312 1 0 decap_w0
xfeed_8311 1 0 decap_w0
xfeed_8310 1 0 decap_w0
xfeed_4009 1 0 decap_w0
xfeed_4008 1 0 decap_w0
xfeed_4007 1 0 decap_w0
xfeed_4006 1 0 decap_w0
xfeed_4005 1 0 decap_w0
xfeed_4004 1 0 decap_w0
xfeed_4003 1 0 decap_w0
xfeed_4002 1 0 decap_w0
xfeed_4001 1 0 decap_w0
xfeed_4000 1 0 decap_w0
xfeed_3399 1 0 decap_w0
xfeed_3398 1 0 decap_w0
xfeed_3397 1 0 decap_w0
xfeed_3396 1 0 decap_w0
xfeed_3395 1 0 decap_w0
xfeed_3394 1 0 decap_w0
xfeed_3393 1 0 decap_w0
xfeed_3392 1 0 decap_w0
xfeed_3391 1 0 decap_w0
xfeed_3390 1 0 decap_w0
xfeed_2869 1 0 decap_w0
xfeed_2868 1 0 decap_w0
xfeed_2867 1 0 decap_w0
xfeed_2866 1 0 decap_w0
xfeed_2865 1 0 decap_w0
xfeed_2864 1 0 decap_w0
xfeed_2863 1 0 decap_w0
xfeed_2862 1 0 decap_w0
xfeed_2861 1 0 decap_w0
xfeed_2860 1 0 decap_w0
xfeed_29679 1 0 decap_w0
xfeed_29678 1 0 decap_w0
xfeed_29677 1 0 decap_w0
xfeed_29676 1 0 decap_w0
xfeed_29675 1 0 decap_w0
xfeed_29674 1 0 decap_w0
xfeed_29673 1 0 decap_w0
xfeed_29672 1 0 decap_w0
xfeed_29671 1 0 decap_w0
xfeed_29670 1 0 decap_w0
xfeed_25369 1 0 decap_w0
xfeed_25368 1 0 decap_w0
xfeed_25367 1 0 decap_w0
xfeed_25366 1 0 decap_w0
xfeed_25365 1 0 decap_w0
xfeed_25364 1 0 decap_w0
xfeed_25363 1 0 decap_w0
xfeed_25362 1 0 decap_w0
xfeed_25361 1 0 decap_w0
xfeed_25360 1 0 decap_w0
xfeed_24839 1 0 decap_w0
xfeed_24838 1 0 decap_w0
xfeed_24837 1 0 decap_w0
xfeed_24836 1 0 decap_w0
xfeed_24835 1 0 decap_w0
xfeed_24834 1 0 decap_w0
xfeed_24833 1 0 decap_w0
xfeed_24832 1 0 decap_w0
xfeed_24831 1 0 decap_w0
xfeed_24830 1 0 decap_w0
xfeed_21059 1 0 decap_w0
xfeed_21058 1 0 decap_w0
xfeed_21057 1 0 decap_w0
xfeed_21056 1 0 decap_w0
xfeed_21055 1 0 decap_w0
xfeed_20529 1 0 decap_w0
xfeed_20528 1 0 decap_w0
xfeed_20527 1 0 decap_w0
xfeed_20526 1 0 decap_w0
xfeed_20525 1 0 decap_w0
xfeed_20524 1 0 decap_w0
xfeed_20523 1 0 decap_w0
xfeed_20522 1 0 decap_w0
xfeed_20521 1 0 decap_w0
xfeed_20520 1 0 decap_w0
xfeed_19369 1 0 decap_w0
xfeed_19368 1 0 decap_w0
xfeed_19367 1 0 decap_w0
xfeed_19366 1 0 decap_w0
xfeed_19365 1 0 decap_w0
xfeed_19364 1 0 decap_w0
xfeed_19363 1 0 decap_w0
xfeed_19362 1 0 decap_w0
xfeed_19361 1 0 decap_w0
xfeed_19360 1 0 decap_w0
xfeed_18839 1 0 decap_w0
xfeed_18838 1 0 decap_w0
xfeed_18837 1 0 decap_w0
xfeed_18836 1 0 decap_w0
xfeed_18835 1 0 decap_w0
xfeed_18834 1 0 decap_w0
xfeed_18833 1 0 decap_w0
xfeed_18832 1 0 decap_w0
xfeed_18831 1 0 decap_w0
xfeed_18830 1 0 decap_w0
xfeed_15059 1 0 decap_w0
xfeed_15058 1 0 decap_w0
xfeed_15057 1 0 decap_w0
xfeed_15056 1 0 decap_w0
xfeed_15055 1 0 decap_w0
xfeed_15054 1 0 decap_w0
xfeed_15053 1 0 decap_w0
xfeed_15052 1 0 decap_w0
xfeed_15051 1 0 decap_w0
xfeed_15050 1 0 decap_w0
xfeed_14529 1 0 decap_w0
xfeed_14528 1 0 decap_w0
xfeed_14527 1 0 decap_w0
xfeed_14526 1 0 decap_w0
xfeed_14525 1 0 decap_w0
xfeed_14524 1 0 decap_w0
xfeed_14523 1 0 decap_w0
xfeed_14522 1 0 decap_w0
xfeed_14521 1 0 decap_w0
xfeed_14520 1 0 decap_w0
xfeed_10219 1 0 decap_w0
xfeed_10218 1 0 decap_w0
xfeed_10217 1 0 decap_w0
xfeed_10216 1 0 decap_w0
xfeed_10215 1 0 decap_w0
xfeed_10214 1 0 decap_w0
xfeed_10213 1 0 decap_w0
xfeed_10212 1 0 decap_w0
xfeed_10211 1 0 decap_w0
xfeed_10210 1 0 decap_w0
xfeed_843 1 0 decap_w0
xfeed_842 1 0 decap_w0
xfeed_841 1 0 decap_w0
xfeed_840 1 0 decap_w0
xfeed_844 1 0 decap_w0
xfeed_845 1 0 decap_w0
xfeed_846 1 0 decap_w0
xfeed_847 1 0 decap_w0
xfeed_848 1 0 decap_w0
xfeed_849 1 0 decap_w0
xfeed_31379 1 0 decap_w0
xfeed_31378 1 0 decap_w0
xfeed_31377 1 0 decap_w0
xfeed_31376 1 0 decap_w0
xfeed_31375 1 0 decap_w0
xfeed_31374 1 0 decap_w0
xfeed_31373 1 0 decap_w0
xfeed_31372 1 0 decap_w0
xfeed_31371 1 0 decap_w0
xfeed_31370 1 0 decap_w0
xfeed_30849 1 0 decap_w0
xfeed_30848 1 0 decap_w0
xfeed_30847 1 0 decap_w0
xfeed_30846 1 0 decap_w0
xfeed_30845 1 0 decap_w0
xfeed_30844 1 0 decap_w0
xfeed_30843 1 0 decap_w0
xfeed_30842 1 0 decap_w0
xfeed_30841 1 0 decap_w0
xfeed_30840 1 0 decap_w0
xfeed_21061 1 0 decap_w0
xfeed_21060 1 0 decap_w0
xfeed_8329 1 0 decap_w0
xfeed_8328 1 0 decap_w0
xfeed_8327 1 0 decap_w0
xfeed_8326 1 0 decap_w0
xfeed_8325 1 0 decap_w0
xfeed_8324 1 0 decap_w0
xfeed_8323 1 0 decap_w0
xfeed_8322 1 0 decap_w0
xfeed_8321 1 0 decap_w0
xfeed_8320 1 0 decap_w0
xfeed_4019 1 0 decap_w0
xfeed_4018 1 0 decap_w0
xfeed_4017 1 0 decap_w0
xfeed_4016 1 0 decap_w0
xfeed_4015 1 0 decap_w0
xfeed_4014 1 0 decap_w0
xfeed_4013 1 0 decap_w0
xfeed_4012 1 0 decap_w0
xfeed_4011 1 0 decap_w0
xfeed_4010 1 0 decap_w0
xfeed_2879 1 0 decap_w0
xfeed_2878 1 0 decap_w0
xfeed_2877 1 0 decap_w0
xfeed_2876 1 0 decap_w0
xfeed_2875 1 0 decap_w0
xfeed_2874 1 0 decap_w0
xfeed_2873 1 0 decap_w0
xfeed_2872 1 0 decap_w0
xfeed_2871 1 0 decap_w0
xfeed_2870 1 0 decap_w0
xfeed_29689 1 0 decap_w0
xfeed_29688 1 0 decap_w0
xfeed_29687 1 0 decap_w0
xfeed_29686 1 0 decap_w0
xfeed_29685 1 0 decap_w0
xfeed_29684 1 0 decap_w0
xfeed_29683 1 0 decap_w0
xfeed_29682 1 0 decap_w0
xfeed_29681 1 0 decap_w0
xfeed_29680 1 0 decap_w0
xfeed_25379 1 0 decap_w0
xfeed_25378 1 0 decap_w0
xfeed_25377 1 0 decap_w0
xfeed_25376 1 0 decap_w0
xfeed_25375 1 0 decap_w0
xfeed_25374 1 0 decap_w0
xfeed_25373 1 0 decap_w0
xfeed_25372 1 0 decap_w0
xfeed_25371 1 0 decap_w0
xfeed_25370 1 0 decap_w0
xfeed_24849 1 0 decap_w0
xfeed_24848 1 0 decap_w0
xfeed_24847 1 0 decap_w0
xfeed_24846 1 0 decap_w0
xfeed_24845 1 0 decap_w0
xfeed_24844 1 0 decap_w0
xfeed_24843 1 0 decap_w0
xfeed_24842 1 0 decap_w0
xfeed_24841 1 0 decap_w0
xfeed_24840 1 0 decap_w0
xfeed_21069 1 0 decap_w0
xfeed_21068 1 0 decap_w0
xfeed_21067 1 0 decap_w0
xfeed_21066 1 0 decap_w0
xfeed_21065 1 0 decap_w0
xfeed_21064 1 0 decap_w0
xfeed_21063 1 0 decap_w0
xfeed_21062 1 0 decap_w0
xfeed_20539 1 0 decap_w0
xfeed_20538 1 0 decap_w0
xfeed_20537 1 0 decap_w0
xfeed_20536 1 0 decap_w0
xfeed_20535 1 0 decap_w0
xfeed_20534 1 0 decap_w0
xfeed_20533 1 0 decap_w0
xfeed_20532 1 0 decap_w0
xfeed_20531 1 0 decap_w0
xfeed_20530 1 0 decap_w0
xfeed_19379 1 0 decap_w0
xfeed_19378 1 0 decap_w0
xfeed_19377 1 0 decap_w0
xfeed_19376 1 0 decap_w0
xfeed_19375 1 0 decap_w0
xfeed_19374 1 0 decap_w0
xfeed_19373 1 0 decap_w0
xfeed_19372 1 0 decap_w0
xfeed_19371 1 0 decap_w0
xfeed_19370 1 0 decap_w0
xfeed_18849 1 0 decap_w0
xfeed_18848 1 0 decap_w0
xfeed_18847 1 0 decap_w0
xfeed_18846 1 0 decap_w0
xfeed_18845 1 0 decap_w0
xfeed_18844 1 0 tie
xfeed_18843 1 0 decap_w0
xfeed_18842 1 0 decap_w0
xfeed_18841 1 0 decap_w0
xfeed_18840 1 0 decap_w0
xfeed_15069 1 0 decap_w0
xfeed_15068 1 0 decap_w0
xfeed_15067 1 0 decap_w0
xfeed_15066 1 0 decap_w0
xfeed_15065 1 0 decap_w0
xfeed_15064 1 0 decap_w0
xfeed_15063 1 0 decap_w0
xfeed_15062 1 0 decap_w0
xfeed_15061 1 0 decap_w0
xfeed_15060 1 0 decap_w0
xfeed_14539 1 0 decap_w0
xfeed_14538 1 0 decap_w0
xfeed_14537 1 0 decap_w0
xfeed_14536 1 0 decap_w0
xfeed_14535 1 0 decap_w0
xfeed_14534 1 0 decap_w0
xfeed_14533 1 0 decap_w0
xfeed_14532 1 0 decap_w0
xfeed_14531 1 0 decap_w0
xfeed_14530 1 0 decap_w0
xfeed_10229 1 0 decap_w0
xfeed_10228 1 0 decap_w0
xfeed_10227 1 0 decap_w0
xfeed_10226 1 0 decap_w0
xfeed_10225 1 0 decap_w0
xfeed_10224 1 0 decap_w0
xfeed_10223 1 0 decap_w0
xfeed_10222 1 0 decap_w0
xfeed_10221 1 0 decap_w0
xfeed_10220 1 0 decap_w0
xfeed_850 1 0 decap_w0
xfeed_851 1 0 decap_w0
xfeed_852 1 0 decap_w0
xfeed_853 1 0 decap_w0
xfeed_854 1 0 decap_w0
xfeed_855 1 0 decap_w0
xfeed_856 1 0 decap_w0
xfeed_857 1 0 decap_w0
xfeed_858 1 0 decap_w0
xfeed_859 1 0 decap_w0
xfeed_31389 1 0 decap_w0
xfeed_31388 1 0 decap_w0
xfeed_31387 1 0 decap_w0
xfeed_31386 1 0 decap_w0
xfeed_31385 1 0 decap_w0
xfeed_31384 1 0 decap_w0
xfeed_31383 1 0 decap_w0
xfeed_31382 1 0 decap_w0
xfeed_31381 1 0 decap_w0
xfeed_31380 1 0 decap_w0
xfeed_30856 1 0 decap_w0
xfeed_30855 1 0 decap_w0
xfeed_30854 1 0 decap_w0
xfeed_30853 1 0 decap_w0
xfeed_30852 1 0 decap_w0
xfeed_30851 1 0 decap_w0
xfeed_30850 1 0 decap_w0
xfeed_8339 1 0 decap_w0
xfeed_8338 1 0 decap_w0
xfeed_8337 1 0 decap_w0
xfeed_8336 1 0 decap_w0
xfeed_8335 1 0 decap_w0
xfeed_8334 1 0 decap_w0
xfeed_8333 1 0 decap_w0
xfeed_8332 1 0 decap_w0
xfeed_8331 1 0 decap_w0
xfeed_8330 1 0 decap_w0
xfeed_7809 1 0 decap_w0
xfeed_7808 1 0 decap_w0
xfeed_7807 1 0 decap_w0
xfeed_7806 1 0 decap_w0
xfeed_7805 1 0 decap_w0
xfeed_7804 1 0 decap_w0
xfeed_7803 1 0 decap_w0
xfeed_7802 1 0 decap_w0
xfeed_7801 1 0 decap_w0
xfeed_7800 1 0 decap_w0
xfeed_4029 1 0 decap_w0
xfeed_4028 1 0 decap_w0
xfeed_4027 1 0 decap_w0
xfeed_4026 1 0 decap_w0
xfeed_4025 1 0 decap_w0
xfeed_4024 1 0 decap_w0
xfeed_4023 1 0 decap_w0
xfeed_4022 1 0 decap_w0
xfeed_4021 1 0 decap_w0
xfeed_4020 1 0 decap_w0
xfeed_2889 1 0 decap_w0
xfeed_2888 1 0 decap_w0
xfeed_2887 1 0 decap_w0
xfeed_2886 1 0 decap_w0
xfeed_2885 1 0 decap_w0
xfeed_2884 1 0 decap_w0
xfeed_2883 1 0 decap_w0
xfeed_2882 1 0 decap_w0
xfeed_2881 1 0 decap_w0
xfeed_2880 1 0 decap_w0
xfeed_30859 1 0 decap_w0
xfeed_30858 1 0 decap_w0
xfeed_30857 1 0 decap_w0
xfeed_29699 1 0 decap_w0
xfeed_29698 1 0 decap_w0
xfeed_29697 1 0 decap_w0
xfeed_29696 1 0 decap_w0
xfeed_29695 1 0 decap_w0
xfeed_29694 1 0 decap_w0
xfeed_29693 1 0 decap_w0
xfeed_29692 1 0 decap_w0
xfeed_29691 1 0 decap_w0
xfeed_29690 1 0 decap_w0
xfeed_25389 1 0 decap_w0
xfeed_25388 1 0 decap_w0
xfeed_25387 1 0 decap_w0
xfeed_25386 1 0 decap_w0
xfeed_25385 1 0 decap_w0
xfeed_25384 1 0 decap_w0
xfeed_25383 1 0 decap_w0
xfeed_25382 1 0 decap_w0
xfeed_25381 1 0 decap_w0
xfeed_25380 1 0 decap_w0
xfeed_24859 1 0 decap_w0
xfeed_24858 1 0 decap_w0
xfeed_24857 1 0 decap_w0
xfeed_24856 1 0 decap_w0
xfeed_24855 1 0 decap_w0
xfeed_24854 1 0 decap_w0
xfeed_24853 1 0 decap_w0
xfeed_24852 1 0 decap_w0
xfeed_24851 1 0 decap_w0
xfeed_24850 1 0 decap_w0
xfeed_21079 1 0 decap_w0
xfeed_21078 1 0 decap_w0
xfeed_21077 1 0 decap_w0
xfeed_21076 1 0 decap_w0
xfeed_21075 1 0 decap_w0
xfeed_21074 1 0 decap_w0
xfeed_21073 1 0 decap_w0
xfeed_21072 1 0 decap_w0
xfeed_21071 1 0 decap_w0
xfeed_21070 1 0 decap_w0
xfeed_20549 1 0 decap_w0
xfeed_20548 1 0 decap_w0
xfeed_20547 1 0 decap_w0
xfeed_20546 1 0 decap_w0
xfeed_20545 1 0 decap_w0
xfeed_20544 1 0 decap_w0
xfeed_20543 1 0 decap_w0
xfeed_20542 1 0 decap_w0
xfeed_20541 1 0 decap_w0
xfeed_20540 1 0 decap_w0
xfeed_19389 1 0 decap_w0
xfeed_19388 1 0 decap_w0
xfeed_19387 1 0 decap_w0
xfeed_19386 1 0 decap_w0
xfeed_19385 1 0 decap_w0
xfeed_19384 1 0 decap_w0
xfeed_19383 1 0 decap_w0
xfeed_19382 1 0 decap_w0
xfeed_19381 1 0 decap_w0
xfeed_19380 1 0 decap_w0
xfeed_18859 1 0 decap_w0
xfeed_18858 1 0 decap_w0
xfeed_18857 1 0 decap_w0
xfeed_18856 1 0 decap_w0
xfeed_18855 1 0 decap_w0
xfeed_18854 1 0 decap_w0
xfeed_18853 1 0 decap_w0
xfeed_18852 1 0 decap_w0
xfeed_18851 1 0 decap_w0
xfeed_18850 1 0 decap_w0
xfeed_15079 1 0 decap_w0
xfeed_15078 1 0 decap_w0
xfeed_15077 1 0 decap_w0
xfeed_15076 1 0 decap_w0
xfeed_15075 1 0 decap_w0
xfeed_15074 1 0 decap_w0
xfeed_15073 1 0 decap_w0
xfeed_15072 1 0 decap_w0
xfeed_15071 1 0 decap_w0
xfeed_15070 1 0 decap_w0
xfeed_14549 1 0 decap_w0
xfeed_14548 1 0 decap_w0
xfeed_14547 1 0 decap_w0
xfeed_14546 1 0 decap_w0
xfeed_14545 1 0 decap_w0
xfeed_14544 1 0 decap_w0
xfeed_14543 1 0 decap_w0
xfeed_14542 1 0 decap_w0
xfeed_14541 1 0 decap_w0
xfeed_14540 1 0 decap_w0
xfeed_10239 1 0 decap_w0
xfeed_10238 1 0 decap_w0
xfeed_10237 1 0 decap_w0
xfeed_10236 1 0 decap_w0
xfeed_10235 1 0 decap_w0
xfeed_10234 1 0 decap_w0
xfeed_10233 1 0 decap_w0
xfeed_10232 1 0 decap_w0
xfeed_10231 1 0 decap_w0
xfeed_10230 1 0 decap_w0
xfeed_860 1 0 decap_w0
xfeed_861 1 0 decap_w0
xfeed_862 1 0 decap_w0
xfeed_863 1 0 decap_w0
xfeed_864 1 0 decap_w0
xfeed_865 1 0 decap_w0
xfeed_866 1 0 decap_w0
xfeed_867 1 0 decap_w0
xfeed_868 1 0 decap_w0
xfeed_869 1 0 decap_w0
xfeed_32009 1 0 decap_w0
xfeed_32008 1 0 decap_w0
xfeed_32007 1 0 decap_w0
xfeed_32006 1 0 decap_w0
xfeed_32005 1 0 decap_w0
xfeed_32004 1 0 decap_w0
xfeed_32003 1 0 decap_w0
xfeed_32002 1 0 decap_w0
xfeed_32001 1 0 decap_w0
xfeed_32000 1 0 decap_w0
xfeed_31399 1 0 decap_w0
xfeed_31398 1 0 decap_w0
xfeed_31397 1 0 decap_w0
xfeed_31396 1 0 decap_w0
xfeed_31395 1 0 decap_w0
xfeed_31394 1 0 decap_w0
xfeed_31393 1 0 decap_w0
xfeed_31392 1 0 decap_w0
xfeed_31391 1 0 decap_w0
xfeed_31390 1 0 decap_w0
xfeed_30863 1 0 decap_w0
xfeed_30862 1 0 decap_w0
xfeed_30861 1 0 decap_w0
xfeed_30860 1 0 decap_w0
xfeed_26009 1 0 decap_w0
xfeed_26008 1 0 decap_w0
xfeed_26007 1 0 decap_w0
xfeed_26006 1 0 decap_w0
xfeed_26005 1 0 decap_w0
xfeed_26004 1 0 decap_w0
xfeed_26003 1 0 decap_w0
xfeed_26002 1 0 decap_w0
xfeed_26001 1 0 decap_w0
xfeed_26000 1 0 decap_w0
xfeed_8349 1 0 decap_w0
xfeed_8348 1 0 decap_w0
xfeed_8347 1 0 decap_w0
xfeed_8346 1 0 decap_w0
xfeed_8345 1 0 decap_w0
xfeed_8344 1 0 decap_w0
xfeed_8343 1 0 decap_w0
xfeed_8342 1 0 decap_w0
xfeed_8341 1 0 decap_w0
xfeed_8340 1 0 decap_w0
xfeed_7819 1 0 decap_w0
xfeed_7818 1 0 decap_w0
xfeed_7817 1 0 decap_w0
xfeed_7816 1 0 decap_w0
xfeed_7815 1 0 decap_w0
xfeed_7814 1 0 decap_w0
xfeed_7813 1 0 tie
xfeed_7812 1 0 decap_w0
xfeed_7811 1 0 decap_w0
xfeed_7810 1 0 decap_w0
xfeed_4039 1 0 decap_w0
xfeed_4038 1 0 decap_w0
xfeed_4037 1 0 decap_w0
xfeed_4036 1 0 decap_w0
xfeed_4035 1 0 decap_w0
xfeed_4034 1 0 decap_w0
xfeed_4033 1 0 decap_w0
xfeed_4032 1 0 decap_w0
xfeed_4031 1 0 decap_w0
xfeed_4030 1 0 decap_w0
xfeed_3509 1 0 decap_w0
xfeed_3508 1 0 decap_w0
xfeed_3507 1 0 decap_w0
xfeed_3506 1 0 decap_w0
xfeed_3505 1 0 decap_w0
xfeed_3504 1 0 decap_w0
xfeed_3503 1 0 decap_w0
xfeed_3502 1 0 decap_w0
xfeed_3501 1 0 decap_w0
xfeed_3500 1 0 decap_w0
xfeed_2899 1 0 decap_w0
xfeed_2898 1 0 decap_w0
xfeed_2897 1 0 decap_w0
xfeed_2896 1 0 decap_w0
xfeed_2895 1 0 decap_w0
xfeed_2894 1 0 decap_w0
xfeed_2893 1 0 decap_w0
xfeed_2892 1 0 decap_w0
xfeed_2891 1 0 decap_w0
xfeed_2890 1 0 decap_w0
xfeed_30869 1 0 decap_w0
xfeed_30868 1 0 decap_w0
xfeed_30867 1 0 decap_w0
xfeed_30866 1 0 decap_w0
xfeed_30865 1 0 decap_w0
xfeed_30864 1 0 decap_w0
xfeed_25399 1 0 decap_w0
xfeed_25398 1 0 decap_w0
xfeed_25397 1 0 decap_w0
xfeed_25396 1 0 decap_w0
xfeed_25395 1 0 decap_w0
xfeed_25394 1 0 decap_w0
xfeed_25393 1 0 decap_w0
xfeed_25392 1 0 decap_w0
xfeed_25391 1 0 decap_w0
xfeed_25390 1 0 decap_w0
xfeed_24869 1 0 decap_w0
xfeed_24868 1 0 decap_w0
xfeed_24867 1 0 decap_w0
xfeed_24866 1 0 decap_w0
xfeed_24865 1 0 decap_w0
xfeed_24864 1 0 decap_w0
xfeed_24863 1 0 decap_w0
xfeed_24862 1 0 decap_w0
xfeed_24861 1 0 decap_w0
xfeed_24860 1 0 decap_w0
xfeed_21089 1 0 decap_w0
xfeed_21088 1 0 decap_w0
xfeed_21087 1 0 decap_w0
xfeed_21086 1 0 decap_w0
xfeed_21085 1 0 decap_w0
xfeed_21084 1 0 decap_w0
xfeed_21083 1 0 decap_w0
xfeed_21082 1 0 decap_w0
xfeed_21081 1 0 decap_w0
xfeed_21080 1 0 decap_w0
xfeed_20559 1 0 decap_w0
xfeed_20558 1 0 decap_w0
xfeed_20557 1 0 decap_w0
xfeed_20556 1 0 decap_w0
xfeed_20555 1 0 decap_w0
xfeed_20554 1 0 decap_w0
xfeed_20553 1 0 decap_w0
xfeed_20552 1 0 decap_w0
xfeed_20551 1 0 decap_w0
xfeed_20550 1 0 decap_w0
xfeed_19399 1 0 decap_w0
xfeed_19398 1 0 decap_w0
xfeed_19397 1 0 decap_w0
xfeed_19396 1 0 decap_w0
xfeed_19395 1 0 decap_w0
xfeed_19394 1 0 decap_w0
xfeed_19393 1 0 decap_w0
xfeed_19392 1 0 decap_w0
xfeed_19391 1 0 decap_w0
xfeed_19390 1 0 decap_w0
xfeed_18869 1 0 decap_w0
xfeed_18868 1 0 decap_w0
xfeed_18867 1 0 decap_w0
xfeed_18866 1 0 decap_w0
xfeed_18865 1 0 decap_w0
xfeed_18864 1 0 decap_w0
xfeed_18863 1 0 decap_w0
xfeed_18862 1 0 decap_w0
xfeed_18861 1 0 decap_w0
xfeed_18860 1 0 decap_w0
xfeed_15089 1 0 decap_w0
xfeed_15088 1 0 decap_w0
xfeed_15087 1 0 decap_w0
xfeed_15086 1 0 decap_w0
xfeed_15085 1 0 decap_w0
xfeed_15084 1 0 decap_w0
xfeed_15083 1 0 decap_w0
xfeed_15082 1 0 decap_w0
xfeed_15081 1 0 decap_w0
xfeed_15080 1 0 decap_w0
xfeed_14559 1 0 decap_w0
xfeed_14558 1 0 decap_w0
xfeed_14557 1 0 decap_w0
xfeed_14556 1 0 decap_w0
xfeed_14555 1 0 decap_w0
xfeed_14554 1 0 decap_w0
xfeed_14553 1 0 decap_w0
xfeed_14552 1 0 decap_w0
xfeed_14551 1 0 decap_w0
xfeed_14550 1 0 decap_w0
xfeed_10249 1 0 decap_w0
xfeed_10248 1 0 decap_w0
xfeed_10247 1 0 decap_w0
xfeed_10246 1 0 decap_w0
xfeed_10245 1 0 decap_w0
xfeed_10244 1 0 decap_w0
xfeed_10243 1 0 decap_w0
xfeed_10242 1 0 decap_w0
xfeed_10241 1 0 decap_w0
xfeed_10240 1 0 decap_w0
xfeed_870 1 0 decap_w0
xfeed_871 1 0 decap_w0
xfeed_872 1 0 decap_w0
xfeed_873 1 0 decap_w0
xfeed_874 1 0 decap_w0
xfeed_875 1 0 decap_w0
xfeed_876 1 0 decap_w0
xfeed_877 1 0 decap_w0
xfeed_878 1 0 decap_w0
xfeed_879 1 0 decap_w0
xfeed_32019 1 0 decap_w0
xfeed_32018 1 0 decap_w0
xfeed_32017 1 0 decap_w0
xfeed_32016 1 0 decap_w0
xfeed_32015 1 0 decap_w0
xfeed_32014 1 0 decap_w0
xfeed_32013 1 0 decap_w0
xfeed_32012 1 0 decap_w0
xfeed_32011 1 0 decap_w0
xfeed_32010 1 0 decap_w0
xfeed_30870 1 0 decap_w0
xfeed_26019 1 0 decap_w0
xfeed_26018 1 0 decap_w0
xfeed_26017 1 0 decap_w0
xfeed_26016 1 0 decap_w0
xfeed_26015 1 0 decap_w0
xfeed_26014 1 0 decap_w0
xfeed_26013 1 0 decap_w0
xfeed_26012 1 0 decap_w0
xfeed_26011 1 0 decap_w0
xfeed_26010 1 0 decap_w0
xfeed_8359 1 0 decap_w0
xfeed_8358 1 0 decap_w0
xfeed_8357 1 0 decap_w0
xfeed_8356 1 0 decap_w0
xfeed_8355 1 0 decap_w0
xfeed_8354 1 0 decap_w0
xfeed_8353 1 0 decap_w0
xfeed_8352 1 0 decap_w0
xfeed_8351 1 0 decap_w0
xfeed_8350 1 0 decap_w0
xfeed_7829 1 0 decap_w0
xfeed_7828 1 0 decap_w0
xfeed_7827 1 0 decap_w0
xfeed_7826 1 0 decap_w0
xfeed_7825 1 0 decap_w0
xfeed_7824 1 0 decap_w0
xfeed_7823 1 0 decap_w0
xfeed_7822 1 0 decap_w0
xfeed_7821 1 0 decap_w0
xfeed_7820 1 0 decap_w0
xfeed_4049 1 0 decap_w0
xfeed_4048 1 0 decap_w0
xfeed_4047 1 0 decap_w0
xfeed_4046 1 0 decap_w0
xfeed_4045 1 0 decap_w0
xfeed_4044 1 0 decap_w0
xfeed_4043 1 0 decap_w0
xfeed_4042 1 0 decap_w0
xfeed_4041 1 0 decap_w0
xfeed_4040 1 0 decap_w0
xfeed_3519 1 0 decap_w0
xfeed_3518 1 0 decap_w0
xfeed_3517 1 0 decap_w0
xfeed_3516 1 0 decap_w0
xfeed_3515 1 0 decap_w0
xfeed_3514 1 0 decap_w0
xfeed_3513 1 0 decap_w0
xfeed_3512 1 0 decap_w0
xfeed_3511 1 0 decap_w0
xfeed_3510 1 0 decap_w0
xfeed_30879 1 0 decap_w0
xfeed_30878 1 0 decap_w0
xfeed_30877 1 0 decap_w0
xfeed_30876 1 0 decap_w0
xfeed_30875 1 0 decap_w0
xfeed_30874 1 0 decap_w0
xfeed_30873 1 0 decap_w0
xfeed_30872 1 0 decap_w0
xfeed_30871 1 0 decap_w0
xfeed_24879 1 0 decap_w0
xfeed_24878 1 0 decap_w0
xfeed_24877 1 0 decap_w0
xfeed_24876 1 0 decap_w0
xfeed_24875 1 0 decap_w0
xfeed_24874 1 0 decap_w0
xfeed_24873 1 0 decap_w0
xfeed_24872 1 0 decap_w0
xfeed_24871 1 0 decap_w0
xfeed_24870 1 0 decap_w0
xfeed_21099 1 0 decap_w0
xfeed_21098 1 0 decap_w0
xfeed_21097 1 0 decap_w0
xfeed_21096 1 0 decap_w0
xfeed_21095 1 0 decap_w0
xfeed_21094 1 0 decap_w0
xfeed_21093 1 0 decap_w0
xfeed_21092 1 0 decap_w0
xfeed_21091 1 0 decap_w0
xfeed_21090 1 0 decap_w0
xfeed_20569 1 0 decap_w0
xfeed_20568 1 0 decap_w0
xfeed_20567 1 0 decap_w0
xfeed_20566 1 0 decap_w0
xfeed_20565 1 0 decap_w0
xfeed_20564 1 0 decap_w0
xfeed_20563 1 0 decap_w0
xfeed_20562 1 0 decap_w0
xfeed_20561 1 0 decap_w0
xfeed_20560 1 0 decap_w0
xfeed_18879 1 0 decap_w0
xfeed_18878 1 0 decap_w0
xfeed_18877 1 0 decap_w0
xfeed_18876 1 0 decap_w0
xfeed_18875 1 0 decap_w0
xfeed_18874 1 0 decap_w0
xfeed_18873 1 0 decap_w0
xfeed_18872 1 0 decap_w0
xfeed_18871 1 0 decap_w0
xfeed_18870 1 0 decap_w0
xfeed_15099 1 0 decap_w0
xfeed_15098 1 0 decap_w0
xfeed_15097 1 0 decap_w0
xfeed_15096 1 0 decap_w0
xfeed_15095 1 0 decap_w0
xfeed_15094 1 0 decap_w0
xfeed_15093 1 0 decap_w0
xfeed_15092 1 0 decap_w0
xfeed_15091 1 0 decap_w0
xfeed_15090 1 0 decap_w0
xfeed_14569 1 0 decap_w0
xfeed_14568 1 0 decap_w0
xfeed_14567 1 0 decap_w0
xfeed_14566 1 0 decap_w0
xfeed_14565 1 0 decap_w0
xfeed_14564 1 0 decap_w0
xfeed_14563 1 0 decap_w0
xfeed_14562 1 0 decap_w0
xfeed_14561 1 0 decap_w0
xfeed_14560 1 0 decap_w0
xfeed_10259 1 0 decap_w0
xfeed_10258 1 0 decap_w0
xfeed_10257 1 0 decap_w0
xfeed_10256 1 0 decap_w0
xfeed_10255 1 0 decap_w0
xfeed_10254 1 0 decap_w0
xfeed_10253 1 0 decap_w0
xfeed_10252 1 0 decap_w0
xfeed_10251 1 0 decap_w0
xfeed_10250 1 0 decap_w0
xsubckt_51_xor2_x0 1 0 35 41 175 xor2_x0
xfeed_880 1 0 decap_w0
xfeed_881 1 0 decap_w0
xfeed_882 1 0 decap_w0
xfeed_883 1 0 decap_w0
xfeed_884 1 0 decap_w0
xfeed_885 1 0 decap_w0
xfeed_886 1 0 decap_w0
xfeed_887 1 0 decap_w0
xfeed_888 1 0 decap_w0
xfeed_889 1 0 decap_w0
xfeed_32029 1 0 decap_w0
xfeed_32028 1 0 decap_w0
xfeed_32027 1 0 decap_w0
xfeed_32026 1 0 decap_w0
xfeed_32025 1 0 decap_w0
xfeed_32024 1 0 decap_w0
xfeed_32023 1 0 decap_w0
xfeed_32022 1 0 decap_w0
xfeed_32021 1 0 decap_w0
xfeed_32020 1 0 decap_w0
xfeed_26026 1 0 decap_w0
xfeed_26025 1 0 decap_w0
xfeed_26024 1 0 decap_w0
xfeed_26023 1 0 decap_w0
xfeed_26022 1 0 decap_w0
xfeed_26021 1 0 decap_w0
xfeed_26020 1 0 decap_w0
xfeed_8369 1 0 decap_w0
xfeed_8368 1 0 decap_w0
xfeed_8367 1 0 decap_w0
xfeed_8366 1 0 decap_w0
xfeed_8365 1 0 decap_w0
xfeed_8364 1 0 decap_w0
xfeed_8363 1 0 decap_w0
xfeed_8362 1 0 decap_w0
xfeed_8361 1 0 decap_w0
xfeed_8360 1 0 decap_w0
xfeed_7839 1 0 decap_w0
xfeed_7838 1 0 decap_w0
xfeed_7837 1 0 decap_w0
xfeed_7836 1 0 decap_w0
xfeed_7835 1 0 decap_w0
xfeed_7834 1 0 decap_w0
xfeed_7833 1 0 decap_w0
xfeed_7832 1 0 decap_w0
xfeed_7831 1 0 decap_w0
xfeed_7830 1 0 decap_w0
xfeed_4059 1 0 decap_w0
xfeed_4058 1 0 decap_w0
xfeed_4057 1 0 decap_w0
xfeed_4056 1 0 decap_w0
xfeed_4055 1 0 decap_w0
xfeed_4054 1 0 decap_w0
xfeed_4053 1 0 decap_w0
xfeed_4052 1 0 decap_w0
xfeed_4051 1 0 decap_w0
xfeed_4050 1 0 decap_w0
xfeed_3529 1 0 decap_w0
xfeed_3528 1 0 decap_w0
xfeed_3527 1 0 decap_w0
xfeed_3526 1 0 decap_w0
xfeed_3525 1 0 decap_w0
xfeed_3524 1 0 decap_w0
xfeed_3523 1 0 decap_w0
xfeed_3522 1 0 decap_w0
xfeed_3521 1 0 decap_w0
xfeed_3520 1 0 decap_w0
xfeed_30889 1 0 decap_w0
xfeed_30888 1 0 decap_w0
xfeed_30887 1 0 decap_w0
xfeed_30886 1 0 decap_w0
xfeed_30885 1 0 decap_w0
xfeed_30884 1 0 decap_w0
xfeed_30883 1 0 decap_w0
xfeed_30882 1 0 decap_w0
xfeed_30881 1 0 decap_w0
xfeed_30880 1 0 decap_w0
xfeed_29809 1 0 decap_w0
xfeed_29808 1 0 decap_w0
xfeed_29807 1 0 decap_w0
xfeed_29806 1 0 decap_w0
xfeed_29805 1 0 decap_w0
xfeed_29804 1 0 decap_w0
xfeed_29803 1 0 decap_w0
xfeed_29802 1 0 decap_w0
xfeed_29801 1 0 decap_w0
xfeed_29800 1 0 decap_w0
xfeed_26029 1 0 decap_w0
xfeed_26028 1 0 decap_w0
xfeed_26027 1 0 decap_w0
xfeed_24889 1 0 decap_w0
xfeed_24888 1 0 decap_w0
xfeed_24887 1 0 decap_w0
xfeed_24886 1 0 decap_w0
xfeed_24885 1 0 decap_w0
xfeed_24884 1 0 decap_w0
xfeed_24883 1 0 decap_w0
xfeed_24882 1 0 decap_w0
xfeed_24881 1 0 decap_w0
xfeed_24880 1 0 decap_w0
xfeed_20579 1 0 decap_w0
xfeed_20578 1 0 decap_w0
xfeed_20577 1 0 decap_w0
xfeed_20576 1 0 decap_w0
xfeed_20575 1 0 decap_w0
xfeed_20574 1 0 decap_w0
xfeed_20573 1 0 decap_w0
xfeed_20572 1 0 decap_w0
xfeed_20571 1 0 decap_w0
xfeed_20570 1 0 decap_w0
xfeed_18887 1 0 decap_w0
xfeed_18886 1 0 decap_w0
xfeed_18885 1 0 decap_w0
xfeed_18884 1 0 decap_w0
xfeed_18883 1 0 decap_w0
xfeed_18882 1 0 decap_w0
xfeed_18881 1 0 decap_w0
xfeed_18880 1 0 decap_w0
xfeed_14579 1 0 decap_w0
xfeed_14578 1 0 decap_w0
xfeed_14577 1 0 decap_w0
xfeed_14576 1 0 decap_w0
xfeed_14575 1 0 decap_w0
xfeed_14574 1 0 decap_w0
xfeed_14573 1 0 decap_w0
xfeed_14572 1 0 decap_w0
xfeed_14571 1 0 decap_w0
xfeed_14570 1 0 decap_w0
xfeed_10269 1 0 decap_w0
xfeed_10268 1 0 decap_w0
xfeed_10267 1 0 decap_w0
xfeed_10266 1 0 decap_w0
xfeed_10265 1 0 decap_w0
xfeed_10264 1 0 decap_w0
xfeed_10263 1 0 decap_w0
xfeed_10262 1 0 decap_w0
xfeed_10261 1 0 decap_w0
xfeed_10260 1 0 decap_w0
xsubckt_47_xor2_x0 1 0 41 52 177 xor2_x0
xfeed_890 1 0 decap_w0
xfeed_891 1 0 decap_w0
xfeed_892 1 0 decap_w0
xfeed_893 1 0 decap_w0
xfeed_894 1 0 decap_w0
xfeed_895 1 0 decap_w0
xfeed_896 1 0 decap_w0
xfeed_897 1 0 decap_w0
xfeed_898 1 0 decap_w0
xfeed_899 1 0 decap_w0
xfeed_32039 1 0 decap_w0
xfeed_32038 1 0 decap_w0
xfeed_32037 1 0 decap_w0
xfeed_32036 1 0 decap_w0
xfeed_32035 1 0 decap_w0
xfeed_32034 1 0 decap_w0
xfeed_32033 1 0 decap_w0
xfeed_32032 1 0 decap_w0
xfeed_32031 1 0 decap_w0
xfeed_32030 1 0 decap_w0
xfeed_31509 1 0 decap_w0
xfeed_31508 1 0 decap_w0
xfeed_31507 1 0 decap_w0
xfeed_31506 1 0 decap_w0
xfeed_31505 1 0 decap_w0
xfeed_31504 1 0 decap_w0
xfeed_31503 1 0 decap_w0
xfeed_31502 1 0 decap_w0
xfeed_31501 1 0 decap_w0
xfeed_31500 1 0 decap_w0
xfeed_26033 1 0 decap_w0
xfeed_26032 1 0 decap_w0
xfeed_26031 1 0 decap_w0
xfeed_26030 1 0 decap_w0
xfeed_18889 1 0 decap_w0
xfeed_18888 1 0 decap_w0
xfeed_8379 1 0 decap_w0
xfeed_8378 1 0 decap_w0
xfeed_8377 1 0 decap_w0
xfeed_8376 1 0 decap_w0
xfeed_8375 1 0 decap_w0
xfeed_8374 1 0 decap_w0
xfeed_8373 1 0 decap_w0
xfeed_8372 1 0 decap_w0
xfeed_8371 1 0 decap_w0
xfeed_8370 1 0 decap_w0
xfeed_7849 1 0 decap_w0
xfeed_7848 1 0 decap_w0
xfeed_7847 1 0 decap_w0
xfeed_7846 1 0 decap_w0
xfeed_7845 1 0 decap_w0
xfeed_7844 1 0 decap_w0
xfeed_7843 1 0 decap_w0
xfeed_7842 1 0 decap_w0
xfeed_7841 1 0 decap_w0
xfeed_7840 1 0 decap_w0
xfeed_4069 1 0 decap_w0
xfeed_4068 1 0 decap_w0
xfeed_4067 1 0 decap_w0
xfeed_4066 1 0 decap_w0
xfeed_4065 1 0 decap_w0
xfeed_4064 1 0 decap_w0
xfeed_4063 1 0 decap_w0
xfeed_4062 1 0 decap_w0
xfeed_4061 1 0 decap_w0
xfeed_4060 1 0 decap_w0
xfeed_3539 1 0 decap_w0
xfeed_3538 1 0 decap_w0
xfeed_3537 1 0 decap_w0
xfeed_3536 1 0 decap_w0
xfeed_3535 1 0 decap_w0
xfeed_3534 1 0 decap_w0
xfeed_3533 1 0 decap_w0
xfeed_3532 1 0 decap_w0
xfeed_3531 1 0 decap_w0
xfeed_3530 1 0 decap_w0
xfeed_30899 1 0 decap_w0
xfeed_30898 1 0 decap_w0
xfeed_30897 1 0 decap_w0
xfeed_30896 1 0 decap_w0
xfeed_30895 1 0 decap_w0
xfeed_30894 1 0 decap_w0
xfeed_30893 1 0 decap_w0
xfeed_30892 1 0 decap_w0
xfeed_30891 1 0 decap_w0
xfeed_30890 1 0 decap_w0
xfeed_29819 1 0 decap_w0
xfeed_29818 1 0 decap_w0
xfeed_29817 1 0 decap_w0
xfeed_29816 1 0 decap_w0
xfeed_29815 1 0 decap_w0
xfeed_29814 1 0 decap_w0
xfeed_29813 1 0 decap_w0
xfeed_29812 1 0 decap_w0
xfeed_29811 1 0 decap_w0
xfeed_29810 1 0 decap_w0
xfeed_26039 1 0 decap_w0
xfeed_26038 1 0 decap_w0
xfeed_26037 1 0 decap_w0
xfeed_26036 1 0 decap_w0
xfeed_26035 1 0 decap_w0
xfeed_26034 1 0 decap_w0
xfeed_25509 1 0 decap_w0
xfeed_25508 1 0 decap_w0
xfeed_25507 1 0 decap_w0
xfeed_25506 1 0 decap_w0
xfeed_25505 1 0 decap_w0
xfeed_25504 1 0 decap_w0
xfeed_25503 1 0 decap_w0
xfeed_25502 1 0 decap_w0
xfeed_25501 1 0 decap_w0
xfeed_25500 1 0 decap_w0
xfeed_24899 1 0 decap_w0
xfeed_24898 1 0 decap_w0
xfeed_24897 1 0 decap_w0
xfeed_24896 1 0 decap_w0
xfeed_24895 1 0 decap_w0
xfeed_24894 1 0 decap_w0
xfeed_24893 1 0 tie
xfeed_24892 1 0 decap_w0
xfeed_24891 1 0 decap_w0
xfeed_24890 1 0 decap_w0
xfeed_20589 1 0 decap_w0
xfeed_20588 1 0 decap_w0
xfeed_20587 1 0 decap_w0
xfeed_20586 1 0 decap_w0
xfeed_20585 1 0 decap_w0
xfeed_20584 1 0 decap_w0
xfeed_20583 1 0 decap_w0
xfeed_20582 1 0 decap_w0
xfeed_20581 1 0 decap_w0
xfeed_20580 1 0 decap_w0
xfeed_19509 1 0 decap_w0
xfeed_19508 1 0 decap_w0
xfeed_19507 1 0 decap_w0
xfeed_19506 1 0 decap_w0
xfeed_19505 1 0 decap_w0
xfeed_19504 1 0 decap_w0
xfeed_19503 1 0 decap_w0
xfeed_19502 1 0 decap_w0
xfeed_19501 1 0 decap_w0
xfeed_19500 1 0 decap_w0
xfeed_18894 1 0 decap_w0
xfeed_18893 1 0 decap_w0
xfeed_18892 1 0 decap_w0
xfeed_18891 1 0 decap_w0
xfeed_18890 1 0 decap_w0
xfeed_14589 1 0 decap_w0
xfeed_14588 1 0 decap_w0
xfeed_14587 1 0 decap_w0
xfeed_14586 1 0 decap_w0
xfeed_14585 1 0 decap_w0
xfeed_14584 1 0 decap_w0
xfeed_14583 1 0 decap_w0
xfeed_14582 1 0 decap_w0
xfeed_14581 1 0 decap_w0
xfeed_14580 1 0 decap_w0
xfeed_10279 1 0 decap_w0
xfeed_10278 1 0 decap_w0
xfeed_10277 1 0 decap_w0
xfeed_10276 1 0 decap_w0
xfeed_10275 1 0 decap_w0
xfeed_10274 1 0 decap_w0
xfeed_10273 1 0 decap_w0
xfeed_10272 1 0 decap_w0
xfeed_10271 1 0 decap_w0
xfeed_10270 1 0 decap_w0
xfeed_32049 1 0 decap_w0
xfeed_32048 1 0 decap_w0
xfeed_32047 1 0 decap_w0
xfeed_32046 1 0 decap_w0
xfeed_32045 1 0 decap_w0
xfeed_32044 1 0 decap_w0
xfeed_32043 1 0 decap_w0
xfeed_32042 1 0 decap_w0
xfeed_32041 1 0 decap_w0
xfeed_32040 1 0 decap_w0
xfeed_31519 1 0 decap_w0
xfeed_31518 1 0 decap_w0
xfeed_31517 1 0 decap_w0
xfeed_31516 1 0 decap_w0
xfeed_31515 1 0 decap_w0
xfeed_31514 1 0 decap_w0
xfeed_31513 1 0 decap_w0
xfeed_31512 1 0 decap_w0
xfeed_31511 1 0 decap_w0
xfeed_31510 1 0 decap_w0
xfeed_26040 1 0 decap_w0
xfeed_21201 1 0 decap_w0
xfeed_21200 1 0 decap_w0
xfeed_18899 1 0 decap_w0
xfeed_18898 1 0 decap_w0
xfeed_18897 1 0 decap_w0
xfeed_18896 1 0 decap_w0
xfeed_18895 1 0 decap_w0
xfeed_8389 1 0 decap_w0
xfeed_8388 1 0 decap_w0
xfeed_8387 1 0 decap_w0
xfeed_8386 1 0 decap_w0
xfeed_8385 1 0 decap_w0
xfeed_8384 1 0 decap_w0
xfeed_8383 1 0 decap_w0
xfeed_8382 1 0 decap_w0
xfeed_8381 1 0 decap_w0
xfeed_8380 1 0 decap_w0
xfeed_7859 1 0 decap_w0
xfeed_7858 1 0 decap_w0
xfeed_7857 1 0 decap_w0
xfeed_7856 1 0 decap_w0
xfeed_7855 1 0 decap_w0
xfeed_7854 1 0 decap_w0
xfeed_7853 1 0 decap_w0
xfeed_7852 1 0 decap_w0
xfeed_7851 1 0 decap_w0
xfeed_7850 1 0 decap_w0
xfeed_4079 1 0 decap_w0
xfeed_4078 1 0 decap_w0
xfeed_4077 1 0 decap_w0
xfeed_4076 1 0 decap_w0
xfeed_4075 1 0 decap_w0
xfeed_4074 1 0 decap_w0
xfeed_4073 1 0 decap_w0
xfeed_4072 1 0 decap_w0
xfeed_4071 1 0 decap_w0
xfeed_4070 1 0 decap_w0
xfeed_3549 1 0 decap_w0
xfeed_3548 1 0 decap_w0
xfeed_3547 1 0 decap_w0
xfeed_3546 1 0 decap_w0
xfeed_3545 1 0 decap_w0
xfeed_3544 1 0 decap_w0
xfeed_3543 1 0 decap_w0
xfeed_3542 1 0 decap_w0
xfeed_3541 1 0 decap_w0
xfeed_3540 1 0 decap_w0
xsubckt_30_inv_x0 1 0 119 27 inv_x0
xfeed_29829 1 0 decap_w0
xfeed_29828 1 0 decap_w0
xfeed_29827 1 0 decap_w0
xfeed_29826 1 0 tie
xfeed_29825 1 0 decap_w0
xfeed_29824 1 0 decap_w0
xfeed_29823 1 0 decap_w0
xfeed_29822 1 0 decap_w0
xfeed_29821 1 0 decap_w0
xfeed_29820 1 0 decap_w0
xfeed_26049 1 0 decap_w0
xfeed_26048 1 0 decap_w0
xfeed_26047 1 0 decap_w0
xfeed_26046 1 0 decap_w0
xfeed_26045 1 0 decap_w0
xfeed_26044 1 0 decap_w0
xfeed_26043 1 0 decap_w0
xfeed_26042 1 0 decap_w0
xfeed_26041 1 0 decap_w0
xfeed_25519 1 0 decap_w0
xfeed_25518 1 0 decap_w0
xfeed_25517 1 0 decap_w0
xfeed_25516 1 0 decap_w0
xfeed_25515 1 0 decap_w0
xfeed_25514 1 0 decap_w0
xfeed_25513 1 0 decap_w0
xfeed_25512 1 0 decap_w0
xfeed_25511 1 0 decap_w0
xfeed_25510 1 0 decap_w0
xfeed_21209 1 0 decap_w0
xfeed_21208 1 0 decap_w0
xfeed_21207 1 0 decap_w0
xfeed_21206 1 0 decap_w0
xfeed_21205 1 0 decap_w0
xfeed_21204 1 0 decap_w0
xfeed_21203 1 0 decap_w0
xfeed_21202 1 0 decap_w0
xfeed_20599 1 0 decap_w0
xfeed_20598 1 0 decap_w0
xfeed_20597 1 0 decap_w0
xfeed_20596 1 0 decap_w0
xfeed_20595 1 0 decap_w0
xfeed_20594 1 0 decap_w0
xfeed_20593 1 0 decap_w0
xfeed_20592 1 0 decap_w0
xfeed_20591 1 0 decap_w0
xfeed_20590 1 0 decap_w0
xfeed_19519 1 0 decap_w0
xfeed_19518 1 0 decap_w0
xfeed_19517 1 0 decap_w0
xfeed_19516 1 0 decap_w0
xfeed_19515 1 0 decap_w0
xfeed_19514 1 0 decap_w0
xfeed_19513 1 0 decap_w0
xfeed_19512 1 0 decap_w0
xfeed_19511 1 0 decap_w0
xfeed_19510 1 0 decap_w0
xfeed_15209 1 0 decap_w0
xfeed_15208 1 0 decap_w0
xfeed_15207 1 0 decap_w0
xfeed_15206 1 0 decap_w0
xfeed_15205 1 0 decap_w0
xfeed_15204 1 0 decap_w0
xfeed_15203 1 0 decap_w0
xfeed_15202 1 0 decap_w0
xfeed_15201 1 0 decap_w0
xfeed_15200 1 0 decap_w0
xfeed_14599 1 0 decap_w0
xfeed_14598 1 0 decap_w0
xfeed_14597 1 0 decap_w0
xfeed_14596 1 0 decap_w0
xfeed_14595 1 0 decap_w0
xfeed_14594 1 0 decap_w0
xfeed_14593 1 0 decap_w0
xfeed_14592 1 0 decap_w0
xfeed_14591 1 0 decap_w0
xfeed_14590 1 0 decap_w0
xfeed_10289 1 0 decap_w0
xfeed_10288 1 0 decap_w0
xfeed_10287 1 0 decap_w0
xfeed_10286 1 0 decap_w0
xfeed_10285 1 0 decap_w0
xfeed_10284 1 0 decap_w0
xfeed_10283 1 0 decap_w0
xfeed_10282 1 0 decap_w0
xfeed_10281 1 0 decap_w0
xfeed_10280 1 0 decap_w0
xfeed_32059 1 0 decap_w0
xfeed_32058 1 0 decap_w0
xfeed_32057 1 0 decap_w0
xfeed_32056 1 0 decap_w0
xfeed_32055 1 0 decap_w0
xfeed_32054 1 0 decap_w0
xfeed_32053 1 0 decap_w0
xfeed_32052 1 0 decap_w0
xfeed_32051 1 0 decap_w0
xfeed_32050 1 0 decap_w0
xfeed_31529 1 0 decap_w0
xfeed_31528 1 0 decap_w0
xfeed_31527 1 0 decap_w0
xfeed_31526 1 0 decap_w0
xfeed_31525 1 0 decap_w0
xfeed_31524 1 0 decap_w0
xfeed_31523 1 0 decap_w0
xfeed_31522 1 0 decap_w0
xfeed_31521 1 0 decap_w0
xfeed_31520 1 0 decap_w0
xfeed_9009 1 0 decap_w0
xfeed_9008 1 0 decap_w0
xfeed_9007 1 0 decap_w0
xfeed_9006 1 0 decap_w0
xfeed_9005 1 0 decap_w0
xfeed_9004 1 0 decap_w0
xfeed_9003 1 0 decap_w0
xfeed_9002 1 0 tie
xfeed_9001 1 0 decap_w0
xfeed_9000 1 0 decap_w0
xfeed_8399 1 0 decap_w0
xfeed_8398 1 0 decap_w0
xfeed_8397 1 0 decap_w0
xfeed_8396 1 0 decap_w0
xfeed_8395 1 0 decap_w0
xfeed_8394 1 0 decap_w0
xfeed_8393 1 0 decap_w0
xfeed_8392 1 0 decap_w0
xfeed_8391 1 0 decap_w0
xfeed_8390 1 0 decap_w0
xfeed_7869 1 0 decap_w0
xfeed_7868 1 0 decap_w0
xfeed_7867 1 0 decap_w0
xfeed_7866 1 0 decap_w0
xfeed_7865 1 0 decap_w0
xfeed_7864 1 0 decap_w0
xfeed_7863 1 0 decap_w0
xfeed_7862 1 0 decap_w0
xfeed_7861 1 0 decap_w0
xfeed_7860 1 0 decap_w0
xfeed_4089 1 0 decap_w0
xfeed_4088 1 0 decap_w0
xfeed_4087 1 0 decap_w0
xfeed_4086 1 0 decap_w0
xfeed_4085 1 0 decap_w0
xfeed_4084 1 0 decap_w0
xfeed_4083 1 0 decap_w0
xfeed_4082 1 0 decap_w0
xfeed_4081 1 0 decap_w0
xfeed_4080 1 0 decap_w0
xfeed_3559 1 0 decap_w0
xfeed_3558 1 0 decap_w0
xfeed_3557 1 0 decap_w0
xfeed_3556 1 0 decap_w0
xfeed_3555 1 0 decap_w0
xfeed_3554 1 0 decap_w0
xfeed_3553 1 0 decap_w0
xfeed_3552 1 0 decap_w0
xfeed_3551 1 0 decap_w0
xfeed_3550 1 0 decap_w0
xfeed_29839 1 0 decap_w0
xfeed_29838 1 0 decap_w0
xfeed_29837 1 0 decap_w0
xfeed_29836 1 0 decap_w0
xfeed_29835 1 0 decap_w0
xfeed_29834 1 0 decap_w0
xfeed_29833 1 0 decap_w0
xfeed_29832 1 0 decap_w0
xfeed_29831 1 0 decap_w0
xfeed_29830 1 0 decap_w0
xfeed_26059 1 0 decap_w0
xfeed_26058 1 0 decap_w0
xfeed_26057 1 0 decap_w0
xfeed_26056 1 0 decap_w0
xfeed_26055 1 0 decap_w0
xfeed_26054 1 0 decap_w0
xfeed_26053 1 0 decap_w0
xfeed_26052 1 0 decap_w0
xfeed_26051 1 0 decap_w0
xfeed_26050 1 0 decap_w0
xfeed_25529 1 0 decap_w0
xfeed_25528 1 0 decap_w0
xfeed_25527 1 0 decap_w0
xfeed_25526 1 0 decap_w0
xfeed_25525 1 0 decap_w0
xfeed_25524 1 0 decap_w0
xfeed_25523 1 0 decap_w0
xfeed_25522 1 0 decap_w0
xfeed_25521 1 0 decap_w0
xfeed_25520 1 0 decap_w0
xfeed_21219 1 0 decap_w0
xfeed_21218 1 0 decap_w0
xfeed_21217 1 0 decap_w0
xfeed_21216 1 0 decap_w0
xfeed_21215 1 0 decap_w0
xfeed_21214 1 0 decap_w0
xfeed_21213 1 0 decap_w0
xfeed_21212 1 0 decap_w0
xfeed_21211 1 0 decap_w0
xfeed_21210 1 0 decap_w0
xfeed_19529 1 0 decap_w0
xfeed_19528 1 0 decap_w0
xfeed_19527 1 0 decap_w0
xfeed_19526 1 0 decap_w0
xfeed_19525 1 0 decap_w0
xfeed_19524 1 0 decap_w0
xfeed_19523 1 0 decap_w0
xfeed_19522 1 0 decap_w0
xfeed_19521 1 0 decap_w0
xfeed_19520 1 0 decap_w0
xfeed_15219 1 0 decap_w0
xfeed_15218 1 0 decap_w0
xfeed_15217 1 0 decap_w0
xfeed_15216 1 0 decap_w0
xfeed_15215 1 0 decap_w0
xfeed_15214 1 0 decap_w0
xfeed_15213 1 0 decap_w0
xfeed_15212 1 0 decap_w0
xfeed_15211 1 0 decap_w0
xfeed_15210 1 0 decap_w0
xfeed_10299 1 0 decap_w0
xfeed_10298 1 0 decap_w0
xfeed_10297 1 0 decap_w0
xfeed_10296 1 0 decap_w0
xfeed_10295 1 0 decap_w0
xfeed_10294 1 0 decap_w0
xfeed_10293 1 0 decap_w0
xfeed_10292 1 0 decap_w0
xfeed_10291 1 0 decap_w0
xfeed_10290 1 0 decap_w0
xfeed_32069 1 0 decap_w0
xfeed_32068 1 0 decap_w0
xfeed_32067 1 0 decap_w0
xfeed_32066 1 0 decap_w0
xfeed_32065 1 0 decap_w0
xfeed_32064 1 0 decap_w0
xfeed_32063 1 0 decap_w0
xfeed_32062 1 0 decap_w0
xfeed_32061 1 0 decap_w0
xfeed_32060 1 0 decap_w0
xfeed_31539 1 0 decap_w0
xfeed_31538 1 0 decap_w0
xfeed_31537 1 0 decap_w0
xfeed_31536 1 0 decap_w0
xfeed_31535 1 0 decap_w0
xfeed_31534 1 0 decap_w0
xfeed_31533 1 0 decap_w0
xfeed_31532 1 0 decap_w0
xfeed_31531 1 0 decap_w0
xfeed_31530 1 0 decap_w0
xfeed_9019 1 0 decap_w0
xfeed_9018 1 0 decap_w0
xfeed_9017 1 0 decap_w0
xfeed_9016 1 0 decap_w0
xfeed_9015 1 0 decap_w0
xfeed_9014 1 0 decap_w0
xfeed_9013 1 0 decap_w0
xfeed_9012 1 0 decap_w0
xfeed_9011 1 0 decap_w0
xfeed_9010 1 0 decap_w0
xfeed_7879 1 0 decap_w0
xfeed_7878 1 0 decap_w0
xfeed_7877 1 0 decap_w0
xfeed_7876 1 0 decap_w0
xfeed_7875 1 0 decap_w0
xfeed_7874 1 0 decap_w0
xfeed_7873 1 0 decap_w0
xfeed_7872 1 0 decap_w0
xfeed_7871 1 0 decap_w0
xfeed_7870 1 0 decap_w0
xfeed_4099 1 0 decap_w0
xfeed_4098 1 0 decap_w0
xfeed_4097 1 0 decap_w0
xfeed_4096 1 0 decap_w0
xfeed_4095 1 0 decap_w0
xfeed_4094 1 0 decap_w0
xfeed_4093 1 0 decap_w0
xfeed_4092 1 0 decap_w0
xfeed_4091 1 0 decap_w0
xfeed_4090 1 0 decap_w0
xfeed_3569 1 0 decap_w0
xfeed_3568 1 0 decap_w0
xfeed_3567 1 0 decap_w0
xfeed_3566 1 0 decap_w0
xfeed_3565 1 0 decap_w0
xfeed_3564 1 0 decap_w0
xfeed_3563 1 0 decap_w0
xfeed_3562 1 0 decap_w0
xfeed_3561 1 0 decap_w0
xfeed_3560 1 0 decap_w0
xfeed_29849 1 0 decap_w0
xfeed_29848 1 0 decap_w0
xfeed_29847 1 0 decap_w0
xfeed_29846 1 0 decap_w0
xfeed_29845 1 0 decap_w0
xfeed_29844 1 0 decap_w0
xfeed_29843 1 0 decap_w0
xfeed_29842 1 0 decap_w0
xfeed_29841 1 0 decap_w0
xfeed_29840 1 0 decap_w0
xfeed_26069 1 0 decap_w0
xfeed_26068 1 0 decap_w0
xfeed_26067 1 0 decap_w0
xfeed_26066 1 0 decap_w0
xfeed_26065 1 0 decap_w0
xfeed_26064 1 0 decap_w0
xfeed_26063 1 0 decap_w0
xfeed_26062 1 0 decap_w0
xfeed_26061 1 0 decap_w0
xfeed_26060 1 0 decap_w0
xfeed_25539 1 0 decap_w0
xfeed_25538 1 0 decap_w0
xfeed_25537 1 0 decap_w0
xfeed_25536 1 0 decap_w0
xfeed_25535 1 0 decap_w0
xfeed_25534 1 0 decap_w0
xfeed_25533 1 0 decap_w0
xfeed_25532 1 0 decap_w0
xfeed_25531 1 0 decap_w0
xfeed_25530 1 0 decap_w0
xfeed_21229 1 0 decap_w0
xfeed_21228 1 0 decap_w0
xfeed_21227 1 0 decap_w0
xfeed_21226 1 0 decap_w0
xfeed_21225 1 0 decap_w0
xfeed_21224 1 0 decap_w0
xfeed_21223 1 0 decap_w0
xfeed_21222 1 0 decap_w0
xfeed_21221 1 0 decap_w0
xfeed_21220 1 0 decap_w0
xfeed_19539 1 0 decap_w0
xfeed_19538 1 0 decap_w0
xfeed_19537 1 0 decap_w0
xfeed_19536 1 0 decap_w0
xfeed_19535 1 0 decap_w0
xfeed_19534 1 0 decap_w0
xfeed_19533 1 0 decap_w0
xfeed_19532 1 0 decap_w0
xfeed_19531 1 0 decap_w0
xfeed_19530 1 0 decap_w0
xfeed_15229 1 0 decap_w0
xfeed_15228 1 0 decap_w0
xfeed_15227 1 0 decap_w0
xfeed_15226 1 0 decap_w0
xfeed_15225 1 0 decap_w0
xfeed_15224 1 0 decap_w0
xfeed_15223 1 0 decap_w0
xfeed_15222 1 0 decap_w0
xfeed_15221 1 0 decap_w0
xfeed_15220 1 0 decap_w0
xfeed_32079 1 0 decap_w0
xfeed_32078 1 0 decap_w0
xfeed_32077 1 0 decap_w0
xfeed_32076 1 0 decap_w0
xfeed_32075 1 0 decap_w0
xfeed_32074 1 0 decap_w0
xfeed_32073 1 0 decap_w0
xfeed_32072 1 0 decap_w0
xfeed_32071 1 0 decap_w0
xfeed_32070 1 0 decap_w0
xfeed_31549 1 0 decap_w0
xfeed_31548 1 0 decap_w0
xfeed_31547 1 0 decap_w0
xfeed_31546 1 0 decap_w0
xfeed_31545 1 0 decap_w0
xfeed_31544 1 0 decap_w0
xfeed_31543 1 0 decap_w0
xfeed_31542 1 0 decap_w0
xfeed_31541 1 0 decap_w0
xfeed_31540 1 0 decap_w0
xfeed_9029 1 0 decap_w0
xfeed_9028 1 0 decap_w0
xfeed_9027 1 0 decap_w0
xfeed_9026 1 0 decap_w0
xfeed_9025 1 0 decap_w0
xfeed_9024 1 0 decap_w0
xfeed_9023 1 0 decap_w0
xfeed_9022 1 0 decap_w0
xfeed_9021 1 0 decap_w0
xfeed_9020 1 0 decap_w0
xfeed_7889 1 0 decap_w0
xfeed_7888 1 0 decap_w0
xfeed_7887 1 0 decap_w0
xfeed_7886 1 0 decap_w0
xfeed_7885 1 0 decap_w0
xfeed_7884 1 0 decap_w0
xfeed_7883 1 0 decap_w0
xfeed_7882 1 0 decap_w0
xfeed_7881 1 0 decap_w0
xfeed_7880 1 0 decap_w0
xfeed_3579 1 0 decap_w0
xfeed_3578 1 0 decap_w0
xfeed_3577 1 0 decap_w0
xfeed_3576 1 0 decap_w0
xfeed_3575 1 0 decap_w0
xfeed_3574 1 0 decap_w0
xfeed_3573 1 0 decap_w0
xfeed_3572 1 0 decap_w0
xfeed_3571 1 0 decap_w0
xfeed_3570 1 0 decap_w0
xfeed_29859 1 0 decap_w0
xfeed_29858 1 0 decap_w0
xfeed_29857 1 0 decap_w0
xfeed_29856 1 0 decap_w0
xfeed_29855 1 0 decap_w0
xfeed_29854 1 0 decap_w0
xfeed_29853 1 0 decap_w0
xfeed_29852 1 0 decap_w0
xfeed_29851 1 0 decap_w0
xfeed_29850 1 0 decap_w0
xfeed_26079 1 0 decap_w0
xfeed_26078 1 0 decap_w0
xfeed_26077 1 0 decap_w0
xfeed_26076 1 0 decap_w0
xfeed_26075 1 0 decap_w0
xfeed_26074 1 0 decap_w0
xfeed_26073 1 0 decap_w0
xfeed_26072 1 0 decap_w0
xfeed_26071 1 0 decap_w0
xfeed_26070 1 0 decap_w0
xfeed_25549 1 0 decap_w0
xfeed_25548 1 0 decap_w0
xfeed_25547 1 0 decap_w0
xfeed_25546 1 0 decap_w0
xfeed_25545 1 0 decap_w0
xfeed_25544 1 0 decap_w0
xfeed_25543 1 0 decap_w0
xfeed_25542 1 0 decap_w0
xfeed_25541 1 0 decap_w0
xfeed_25540 1 0 decap_w0
xfeed_21239 1 0 decap_w0
xfeed_21238 1 0 decap_w0
xfeed_21237 1 0 decap_w0
xfeed_21236 1 0 decap_w0
xfeed_21235 1 0 decap_w0
xfeed_21234 1 0 decap_w0
xfeed_21233 1 0 decap_w0
xfeed_21232 1 0 decap_w0
xfeed_21231 1 0 decap_w0
xfeed_21230 1 0 decap_w0
xfeed_20709 1 0 decap_w0
xfeed_20708 1 0 decap_w0
xfeed_20707 1 0 decap_w0
xfeed_20706 1 0 decap_w0
xfeed_20705 1 0 decap_w0
xfeed_20704 1 0 decap_w0
xfeed_20703 1 0 decap_w0
xfeed_20702 1 0 decap_w0
xfeed_20701 1 0 decap_w0
xfeed_20700 1 0 decap_w0
xfeed_19549 1 0 decap_w0
xfeed_19548 1 0 decap_w0
xfeed_19547 1 0 decap_w0
xfeed_19546 1 0 decap_w0
xfeed_19545 1 0 decap_w0
xfeed_19544 1 0 decap_w0
xfeed_19543 1 0 decap_w0
xfeed_19542 1 0 decap_w0
xfeed_19541 1 0 decap_w0
xfeed_19540 1 0 decap_w0
xfeed_15239 1 0 decap_w0
xfeed_15238 1 0 decap_w0
xfeed_15237 1 0 decap_w0
xfeed_15236 1 0 decap_w0
xfeed_15235 1 0 decap_w0
xfeed_15234 1 0 decap_w0
xfeed_15233 1 0 decap_w0
xfeed_15232 1 0 decap_w0
xfeed_15231 1 0 decap_w0
xfeed_15230 1 0 decap_w0
xfeed_14709 1 0 decap_w0
xfeed_14708 1 0 decap_w0
xfeed_14707 1 0 decap_w0
xfeed_14706 1 0 decap_w0
xfeed_14705 1 0 decap_w0
xfeed_14704 1 0 decap_w0
xfeed_14703 1 0 decap_w0
xfeed_14702 1 0 decap_w0
xfeed_14701 1 0 decap_w0
xfeed_14700 1 0 decap_w0
xfeed_32089 1 0 decap_w0
xfeed_32088 1 0 decap_w0
xfeed_32087 1 0 decap_w0
xfeed_32086 1 0 decap_w0
xfeed_32085 1 0 decap_w0
xfeed_32084 1 0 decap_w0
xfeed_32083 1 0 decap_w0
xfeed_32082 1 0 decap_w0
xfeed_32081 1 0 decap_w0
xfeed_32080 1 0 decap_w0
xfeed_31556 1 0 decap_w0
xfeed_31555 1 0 decap_w0
xfeed_31554 1 0 decap_w0
xfeed_31553 1 0 decap_w0
xfeed_31552 1 0 decap_w0
xfeed_31551 1 0 decap_w0
xfeed_31550 1 0 decap_w0
xfeed_9039 1 0 decap_w0
xfeed_9038 1 0 decap_w0
xfeed_9037 1 0 decap_w0
xfeed_9036 1 0 decap_w0
xfeed_9035 1 0 decap_w0
xfeed_9034 1 0 decap_w0
xfeed_9033 1 0 decap_w0
xfeed_9032 1 0 decap_w0
xfeed_9031 1 0 decap_w0
xfeed_9030 1 0 decap_w0
xfeed_8509 1 0 decap_w0
xfeed_8508 1 0 decap_w0
xfeed_8507 1 0 decap_w0
xfeed_8506 1 0 decap_w0
xfeed_8505 1 0 decap_w0
xfeed_8504 1 0 decap_w0
xfeed_8503 1 0 decap_w0
xfeed_8502 1 0 decap_w0
xfeed_8501 1 0 decap_w0
xfeed_8500 1 0 decap_w0
xfeed_7899 1 0 decap_w0
xfeed_7898 1 0 decap_w0
xfeed_7897 1 0 decap_w0
xfeed_7896 1 0 decap_w0
xfeed_7895 1 0 decap_w0
xfeed_7894 1 0 decap_w0
xfeed_7893 1 0 decap_w0
xfeed_7892 1 0 decap_w0
xfeed_7891 1 0 decap_w0
xfeed_7890 1 0 decap_w0
xfeed_3589 1 0 decap_w0
xfeed_3588 1 0 decap_w0
xfeed_3587 1 0 decap_w0
xfeed_3586 1 0 decap_w0
xfeed_3585 1 0 decap_w0
xfeed_3584 1 0 decap_w0
xfeed_3583 1 0 decap_w0
xfeed_3582 1 0 decap_w0
xfeed_3581 1 0 decap_w0
xfeed_3580 1 0 decap_w0
xfeed_31559 1 0 decap_w0
xfeed_31558 1 0 decap_w0
xfeed_31557 1 0 decap_w0
xfeed_29869 1 0 decap_w0
xfeed_29868 1 0 decap_w0
xfeed_29867 1 0 decap_w0
xfeed_29866 1 0 decap_w0
xfeed_29865 1 0 decap_w0
xfeed_29864 1 0 decap_w0
xfeed_29863 1 0 decap_w0
xfeed_29862 1 0 decap_w0
xfeed_29861 1 0 decap_w0
xfeed_29860 1 0 decap_w0
xfeed_26089 1 0 decap_w0
xfeed_26088 1 0 decap_w0
xfeed_26087 1 0 decap_w0
xfeed_26086 1 0 decap_w0
xfeed_26085 1 0 decap_w0
xfeed_26084 1 0 decap_w0
xfeed_26083 1 0 decap_w0
xfeed_26082 1 0 decap_w0
xfeed_26081 1 0 decap_w0
xfeed_26080 1 0 decap_w0
xfeed_25559 1 0 decap_w0
xfeed_25558 1 0 decap_w0
xfeed_25557 1 0 decap_w0
xfeed_25556 1 0 decap_w0
xfeed_25555 1 0 decap_w0
xfeed_25554 1 0 decap_w0
xfeed_25553 1 0 decap_w0
xfeed_25552 1 0 decap_w0
xfeed_25551 1 0 decap_w0
xfeed_25550 1 0 decap_w0
xfeed_21249 1 0 decap_w0
xfeed_21248 1 0 decap_w0
xfeed_21247 1 0 decap_w0
xfeed_21246 1 0 decap_w0
xfeed_21245 1 0 decap_w0
xfeed_21244 1 0 decap_w0
xfeed_21243 1 0 decap_w0
xfeed_21242 1 0 decap_w0
xfeed_21241 1 0 decap_w0
xfeed_21240 1 0 decap_w0
xfeed_20719 1 0 decap_w0
xfeed_20718 1 0 decap_w0
xfeed_20717 1 0 decap_w0
xfeed_20716 1 0 decap_w0
xfeed_20715 1 0 decap_w0
xfeed_20714 1 0 decap_w0
xfeed_20713 1 0 decap_w0
xfeed_20712 1 0 decap_w0
xfeed_20711 1 0 decap_w0
xfeed_20710 1 0 decap_w0
xfeed_19559 1 0 decap_w0
xfeed_19558 1 0 decap_w0
xfeed_19557 1 0 decap_w0
xfeed_19556 1 0 decap_w0
xfeed_19555 1 0 decap_w0
xfeed_19554 1 0 decap_w0
xfeed_19553 1 0 decap_w0
xfeed_19552 1 0 decap_w0
xfeed_19551 1 0 decap_w0
xfeed_19550 1 0 decap_w0
xfeed_15249 1 0 decap_w0
xfeed_15248 1 0 decap_w0
xfeed_15247 1 0 decap_w0
xfeed_15246 1 0 decap_w0
xfeed_15245 1 0 decap_w0
xfeed_15244 1 0 decap_w0
xfeed_15243 1 0 decap_w0
xfeed_15242 1 0 decap_w0
xfeed_15241 1 0 decap_w0
xfeed_15240 1 0 decap_w0
xfeed_14719 1 0 decap_w0
xfeed_14718 1 0 decap_w0
xfeed_14717 1 0 decap_w0
xfeed_14716 1 0 decap_w0
xfeed_14715 1 0 decap_w0
xfeed_14714 1 0 decap_w0
xfeed_14713 1 0 decap_w0
xfeed_14712 1 0 decap_w0
xfeed_14711 1 0 decap_w0
xfeed_14710 1 0 decap_w0
xfeed_10409 1 0 decap_w0
xfeed_10408 1 0 decap_w0
xfeed_10407 1 0 decap_w0
xfeed_10406 1 0 decap_w0
xfeed_10405 1 0 decap_w0
xfeed_10404 1 0 decap_w0
xfeed_10403 1 0 decap_w0
xfeed_10402 1 0 decap_w0
xfeed_10401 1 0 decap_w0
xfeed_10400 1 0 decap_w0
xfeed_32099 1 0 decap_w0
xfeed_32098 1 0 decap_w0
xfeed_32097 1 0 decap_w0
xfeed_32096 1 0 decap_w0
xfeed_32095 1 0 decap_w0
xfeed_32094 1 0 decap_w0
xfeed_32093 1 0 decap_w0
xfeed_32092 1 0 decap_w0
xfeed_32091 1 0 decap_w0
xfeed_32090 1 0 decap_w0
xfeed_31563 1 0 decap_w0
xfeed_31562 1 0 decap_w0
xfeed_31561 1 0 decap_w0
xfeed_31560 1 0 decap_w0
xfeed_9049 1 0 decap_w0
xfeed_9048 1 0 decap_w0
xfeed_9047 1 0 decap_w0
xfeed_9046 1 0 decap_w0
xfeed_9045 1 0 decap_w0
xfeed_9044 1 0 decap_w0
xfeed_9043 1 0 decap_w0
xfeed_9042 1 0 decap_w0
xfeed_9041 1 0 decap_w0
xfeed_9040 1 0 decap_w0
xfeed_8519 1 0 decap_w0
xfeed_8518 1 0 decap_w0
xfeed_8517 1 0 decap_w0
xfeed_8516 1 0 decap_w0
xfeed_8515 1 0 decap_w0
xfeed_8514 1 0 decap_w0
xfeed_8513 1 0 decap_w0
xfeed_8512 1 0 decap_w0
xfeed_8511 1 0 decap_w0
xfeed_8510 1 0 decap_w0
xfeed_4209 1 0 decap_w0
xfeed_4208 1 0 decap_w0
xfeed_4207 1 0 decap_w0
xfeed_4206 1 0 decap_w0
xfeed_4205 1 0 decap_w0
xfeed_4204 1 0 decap_w0
xfeed_4203 1 0 decap_w0
xfeed_4202 1 0 decap_w0
xfeed_4201 1 0 decap_w0
xfeed_4200 1 0 decap_w0
xfeed_3599 1 0 decap_w0
xfeed_3598 1 0 decap_w0
xfeed_3597 1 0 decap_w0
xfeed_3596 1 0 decap_w0
xfeed_3595 1 0 decap_w0
xfeed_3594 1 0 decap_w0
xfeed_3593 1 0 decap_w0
xfeed_3592 1 0 decap_w0
xfeed_3591 1 0 decap_w0
xfeed_3590 1 0 decap_w0
xfeed_31569 1 0 decap_w0
xfeed_31568 1 0 decap_w0
xfeed_31567 1 0 decap_w0
xfeed_31566 1 0 decap_w0
xfeed_31565 1 0 decap_w0
xfeed_31564 1 0 decap_w0
xfeed_29879 1 0 decap_w0
xfeed_29878 1 0 decap_w0
xfeed_29877 1 0 decap_w0
xfeed_29876 1 0 decap_w0
xfeed_29875 1 0 decap_w0
xfeed_29874 1 0 decap_w0
xfeed_29873 1 0 decap_w0
xfeed_29872 1 0 decap_w0
xfeed_29871 1 0 decap_w0
xfeed_29870 1 0 decap_w0
xfeed_26099 1 0 decap_w0
xfeed_26098 1 0 decap_w0
xfeed_26097 1 0 decap_w0
xfeed_26096 1 0 decap_w0
xfeed_26095 1 0 decap_w0
xfeed_26094 1 0 decap_w0
xfeed_26093 1 0 decap_w0
xfeed_26092 1 0 decap_w0
xfeed_26091 1 0 decap_w0
xfeed_26090 1 0 decap_w0
xfeed_25569 1 0 decap_w0
xfeed_25568 1 0 decap_w0
xfeed_25567 1 0 decap_w0
xfeed_25566 1 0 decap_w0
xfeed_25565 1 0 decap_w0
xfeed_25564 1 0 decap_w0
xfeed_25563 1 0 decap_w0
xfeed_25562 1 0 decap_w0
xfeed_25561 1 0 decap_w0
xfeed_25560 1 0 decap_w0
xfeed_21259 1 0 decap_w0
xfeed_21258 1 0 decap_w0
xfeed_21257 1 0 decap_w0
xfeed_21256 1 0 decap_w0
xfeed_21255 1 0 decap_w0
xfeed_21254 1 0 decap_w0
xfeed_21253 1 0 decap_w0
xfeed_21252 1 0 decap_w0
xfeed_21251 1 0 decap_w0
xfeed_21250 1 0 decap_w0
xfeed_20729 1 0 decap_w0
xfeed_20728 1 0 decap_w0
xfeed_20727 1 0 decap_w0
xfeed_20726 1 0 decap_w0
xfeed_20725 1 0 decap_w0
xfeed_20724 1 0 decap_w0
xfeed_20723 1 0 decap_w0
xfeed_20722 1 0 decap_w0
xfeed_20721 1 0 decap_w0
xfeed_20720 1 0 decap_w0
xfeed_19569 1 0 decap_w0
xfeed_19568 1 0 decap_w0
xfeed_19567 1 0 decap_w0
xfeed_19566 1 0 decap_w0
xfeed_19565 1 0 decap_w0
xfeed_19564 1 0 decap_w0
xfeed_19563 1 0 decap_w0
xfeed_19562 1 0 decap_w0
xfeed_19561 1 0 decap_w0
xfeed_19560 1 0 decap_w0
xfeed_15259 1 0 decap_w0
xfeed_15258 1 0 decap_w0
xfeed_15257 1 0 decap_w0
xfeed_15256 1 0 decap_w0
xfeed_15255 1 0 decap_w0
xfeed_15254 1 0 decap_w0
xfeed_15253 1 0 decap_w0
xfeed_15252 1 0 decap_w0
xfeed_15251 1 0 decap_w0
xfeed_15250 1 0 decap_w0
xfeed_14729 1 0 decap_w0
xfeed_14728 1 0 decap_w0
xfeed_14727 1 0 decap_w0
xfeed_14726 1 0 decap_w0
xfeed_14725 1 0 decap_w0
xfeed_14724 1 0 decap_w0
xfeed_14723 1 0 decap_w0
xfeed_14722 1 0 decap_w0
xfeed_14721 1 0 decap_w0
xfeed_14720 1 0 decap_w0
xfeed_10419 1 0 decap_w0
xfeed_10418 1 0 decap_w0
xfeed_10417 1 0 decap_w0
xfeed_10416 1 0 decap_w0
xfeed_10415 1 0 decap_w0
xfeed_10414 1 0 decap_w0
xfeed_10413 1 0 decap_w0
xfeed_10412 1 0 decap_w0
xfeed_10411 1 0 decap_w0
xfeed_10410 1 0 decap_w0
xfeed_31570 1 0 decap_w0
xfeed_9059 1 0 decap_w0
xfeed_9058 1 0 decap_w0
xfeed_9057 1 0 decap_w0
xfeed_9056 1 0 decap_w0
xfeed_9055 1 0 decap_w0
xfeed_9054 1 0 decap_w0
xfeed_9053 1 0 decap_w0
xfeed_9052 1 0 decap_w0
xfeed_9051 1 0 decap_w0
xfeed_9050 1 0 decap_w0
xfeed_8529 1 0 decap_w0
xfeed_8528 1 0 decap_w0
xfeed_8527 1 0 decap_w0
xfeed_8526 1 0 decap_w0
xfeed_8525 1 0 decap_w0
xfeed_8524 1 0 decap_w0
xfeed_8523 1 0 decap_w0
xfeed_8522 1 0 decap_w0
xfeed_8521 1 0 decap_w0
xfeed_8520 1 0 decap_w0
xfeed_4219 1 0 decap_w0
xfeed_4218 1 0 decap_w0
xfeed_4217 1 0 decap_w0
xfeed_4216 1 0 decap_w0
xfeed_4215 1 0 decap_w0
xfeed_4214 1 0 decap_w0
xfeed_4213 1 0 decap_w0
xfeed_4212 1 0 decap_w0
xfeed_4211 1 0 decap_w0
xfeed_4210 1 0 decap_w0
xfeed_31579 1 0 decap_w0
xfeed_31578 1 0 decap_w0
xfeed_31577 1 0 decap_w0
xfeed_31576 1 0 decap_w0
xfeed_31575 1 0 decap_w0
xfeed_31574 1 0 decap_w0
xfeed_31573 1 0 decap_w0
xfeed_31572 1 0 decap_w0
xfeed_31571 1 0 decap_w0
xfeed_29889 1 0 decap_w0
xfeed_29888 1 0 decap_w0
xfeed_29887 1 0 decap_w0
xfeed_29886 1 0 decap_w0
xfeed_29885 1 0 decap_w0
xfeed_29884 1 0 decap_w0
xfeed_29883 1 0 decap_w0
xfeed_29882 1 0 decap_w0
xfeed_29881 1 0 decap_w0
xfeed_29880 1 0 decap_w0
xfeed_25579 1 0 decap_w0
xfeed_25578 1 0 decap_w0
xfeed_25577 1 0 decap_w0
xfeed_25576 1 0 decap_w0
xfeed_25575 1 0 decap_w0
xfeed_25574 1 0 decap_w0
xfeed_25573 1 0 decap_w0
xfeed_25572 1 0 decap_w0
xfeed_25571 1 0 decap_w0
xfeed_25570 1 0 decap_w0
xfeed_21269 1 0 decap_w0
xfeed_21268 1 0 decap_w0
xfeed_21267 1 0 decap_w0
xfeed_21266 1 0 decap_w0
xfeed_21265 1 0 decap_w0
xfeed_21264 1 0 decap_w0
xfeed_21263 1 0 decap_w0
xfeed_21262 1 0 decap_w0
xfeed_21261 1 0 decap_w0
xfeed_21260 1 0 decap_w0
xfeed_20739 1 0 decap_w0
xfeed_20738 1 0 decap_w0
xfeed_20737 1 0 decap_w0
xfeed_20736 1 0 decap_w0
xfeed_20735 1 0 decap_w0
xfeed_20734 1 0 decap_w0
xfeed_20733 1 0 decap_w0
xfeed_20732 1 0 decap_w0
xfeed_20731 1 0 decap_w0
xfeed_20730 1 0 decap_w0
xfeed_19579 1 0 decap_w0
xfeed_19578 1 0 decap_w0
xfeed_19577 1 0 decap_w0
xfeed_19576 1 0 decap_w0
xfeed_19575 1 0 decap_w0
xfeed_19574 1 0 decap_w0
xfeed_19573 1 0 decap_w0
xfeed_19572 1 0 decap_w0
xfeed_19571 1 0 decap_w0
xfeed_19570 1 0 decap_w0
xfeed_15269 1 0 decap_w0
xfeed_15268 1 0 tie
xfeed_15267 1 0 decap_w0
xfeed_15266 1 0 decap_w0
xfeed_15265 1 0 decap_w0
xfeed_15264 1 0 decap_w0
xfeed_15263 1 0 decap_w0
xfeed_15262 1 0 decap_w0
xfeed_15261 1 0 decap_w0
xfeed_15260 1 0 decap_w0
xfeed_14739 1 0 decap_w0
xfeed_14738 1 0 decap_w0
xfeed_14737 1 0 decap_w0
xfeed_14736 1 0 decap_w0
xfeed_14735 1 0 decap_w0
xfeed_14734 1 0 decap_w0
xfeed_14733 1 0 decap_w0
xfeed_14732 1 0 decap_w0
xfeed_14731 1 0 decap_w0
xfeed_14730 1 0 decap_w0
xfeed_10429 1 0 decap_w0
xfeed_10428 1 0 decap_w0
xfeed_10427 1 0 decap_w0
xfeed_10426 1 0 decap_w0
xfeed_10425 1 0 decap_w0
xfeed_10424 1 0 decap_w0
xfeed_10423 1 0 decap_w0
xfeed_10422 1 0 decap_w0
xfeed_10421 1 0 decap_w0
xfeed_10420 1 0 decap_w0
xfeed_10 1 0 decap_w0
xfeed_11 1 0 decap_w0
xfeed_12 1 0 decap_w0
xfeed_13 1 0 decap_w0
xfeed_14 1 0 decap_w0
xfeed_15 1 0 decap_w0
xfeed_16 1 0 decap_w0
xfeed_17 1 0 decap_w0
xfeed_18 1 0 decap_w0
xfeed_19 1 0 decap_w0
xfeed_9069 1 0 decap_w0
xfeed_9068 1 0 decap_w0
xfeed_9067 1 0 decap_w0
xfeed_9066 1 0 decap_w0
xfeed_9065 1 0 decap_w0
xfeed_9064 1 0 decap_w0
xfeed_9063 1 0 decap_w0
xfeed_9062 1 0 decap_w0
xfeed_9061 1 0 decap_w0
xfeed_9060 1 0 decap_w0
xfeed_8539 1 0 decap_w0
xfeed_8538 1 0 decap_w0
xfeed_8537 1 0 decap_w0
xfeed_8536 1 0 decap_w0
xfeed_8535 1 0 decap_w0
xfeed_8534 1 0 decap_w0
xfeed_8533 1 0 decap_w0
xfeed_8532 1 0 decap_w0
xfeed_8531 1 0 decap_w0
xfeed_8530 1 0 decap_w0
xfeed_4229 1 0 decap_w0
xfeed_4228 1 0 decap_w0
xfeed_4227 1 0 decap_w0
xfeed_4226 1 0 decap_w0
xfeed_4225 1 0 decap_w0
xfeed_4224 1 0 decap_w0
xfeed_4223 1 0 decap_w0
xfeed_4222 1 0 decap_w0
xfeed_4221 1 0 decap_w0
xfeed_4220 1 0 decap_w0
xfeed_31589 1 0 decap_w0
xfeed_31588 1 0 decap_w0
xfeed_31587 1 0 decap_w0
xfeed_31586 1 0 decap_w0
xfeed_31585 1 0 decap_w0
xfeed_31584 1 0 decap_w0
xfeed_31583 1 0 decap_w0
xfeed_31582 1 0 decap_w0
xfeed_31581 1 0 decap_w0
xfeed_31580 1 0 decap_w0
xfeed_29899 1 0 decap_w0
xfeed_29898 1 0 decap_w0
xfeed_29897 1 0 decap_w0
xfeed_29896 1 0 decap_w0
xfeed_29895 1 0 decap_w0
xfeed_29894 1 0 decap_w0
xfeed_29893 1 0 decap_w0
xfeed_29892 1 0 decap_w0
xfeed_29891 1 0 decap_w0
xfeed_29890 1 0 decap_w0
xfeed_25589 1 0 decap_w0
xfeed_25588 1 0 decap_w0
xfeed_25587 1 0 decap_w0
xfeed_25586 1 0 decap_w0
xfeed_25585 1 0 decap_w0
xfeed_25584 1 0 decap_w0
xfeed_25583 1 0 decap_w0
xfeed_25582 1 0 decap_w0
xfeed_25581 1 0 decap_w0
xfeed_25580 1 0 decap_w0
xfeed_21279 1 0 decap_w0
xfeed_21278 1 0 decap_w0
xfeed_21277 1 0 decap_w0
xfeed_21276 1 0 decap_w0
xfeed_21275 1 0 decap_w0
xfeed_21274 1 0 decap_w0
xfeed_21273 1 0 decap_w0
xfeed_21272 1 0 decap_w0
xfeed_21271 1 0 decap_w0
xfeed_21270 1 0 decap_w0
xfeed_20749 1 0 decap_w0
xfeed_20748 1 0 decap_w0
xfeed_20747 1 0 decap_w0
xfeed_20746 1 0 decap_w0
xfeed_20745 1 0 decap_w0
xfeed_20744 1 0 decap_w0
xfeed_20743 1 0 decap_w0
xfeed_20742 1 0 decap_w0
xfeed_20741 1 0 decap_w0
xfeed_20740 1 0 decap_w0
xfeed_19587 1 0 decap_w0
xfeed_19586 1 0 decap_w0
xfeed_19585 1 0 decap_w0
xfeed_19584 1 0 decap_w0
xfeed_19583 1 0 decap_w0
xfeed_19582 1 0 decap_w0
xfeed_19581 1 0 decap_w0
xfeed_19580 1 0 decap_w0
xfeed_15279 1 0 decap_w0
xfeed_15278 1 0 decap_w0
xfeed_15277 1 0 decap_w0
xfeed_15276 1 0 decap_w0
xfeed_15275 1 0 decap_w0
xfeed_15274 1 0 decap_w0
xfeed_15273 1 0 decap_w0
xfeed_15272 1 0 decap_w0
xfeed_15271 1 0 decap_w0
xfeed_15270 1 0 decap_w0
xfeed_14748 1 0 decap_w0
xfeed_14747 1 0 decap_w0
xfeed_14746 1 0 decap_w0
xfeed_14745 1 0 decap_w0
xfeed_14744 1 0 decap_w0
xfeed_14743 1 0 decap_w0
xfeed_14742 1 0 decap_w0
xfeed_14741 1 0 decap_w0
xfeed_14740 1 0 decap_w0
xfeed_10439 1 0 decap_w0
xfeed_10438 1 0 decap_w0
xfeed_10437 1 0 decap_w0
xfeed_10436 1 0 decap_w0
xfeed_10435 1 0 decap_w0
xfeed_10434 1 0 decap_w0
xfeed_10433 1 0 decap_w0
xfeed_10432 1 0 decap_w0
xfeed_10431 1 0 decap_w0
xfeed_10430 1 0 decap_w0
xfeed_20 1 0 decap_w0
xfeed_21 1 0 decap_w0
xfeed_22 1 0 decap_w0
xfeed_23 1 0 decap_w0
xfeed_24 1 0 decap_w0
xfeed_25 1 0 decap_w0
xfeed_26 1 0 decap_w0
xfeed_27 1 0 decap_w0
xfeed_28 1 0 decap_w0
xfeed_29 1 0 decap_w0
xfeed_19589 1 0 decap_w0
xfeed_19588 1 0 decap_w0
xfeed_14749 1 0 decap_w0
xfeed_9079 1 0 decap_w0
xfeed_9078 1 0 decap_w0
xfeed_9077 1 0 decap_w0
xfeed_9076 1 0 decap_w0
xfeed_9075 1 0 decap_w0
xfeed_9074 1 0 decap_w0
xfeed_9073 1 0 decap_w0
xfeed_9071 1 0 decap_w0
xfeed_9070 1 0 decap_w0
xfeed_8549 1 0 decap_w0
xfeed_8548 1 0 decap_w0
xfeed_8547 1 0 decap_w0
xfeed_8546 1 0 decap_w0
xfeed_8545 1 0 decap_w0
xfeed_8544 1 0 decap_w0
xfeed_8543 1 0 decap_w0
xfeed_8542 1 0 decap_w0
xfeed_8541 1 0 decap_w0
xfeed_8540 1 0 decap_w0
xfeed_4239 1 0 decap_w0
xfeed_4238 1 0 decap_w0
xfeed_4237 1 0 decap_w0
xfeed_4236 1 0 decap_w0
xfeed_4235 1 0 decap_w0
xfeed_4234 1 0 decap_w0
xfeed_4233 1 0 decap_w0
xfeed_4232 1 0 decap_w0
xfeed_4231 1 0 decap_w0
xfeed_4230 1 0 decap_w0
xfeed_3709 1 0 decap_w0
xfeed_3708 1 0 decap_w0
xfeed_3707 1 0 decap_w0
xfeed_3706 1 0 decap_w0
xfeed_3705 1 0 decap_w0
xfeed_3704 1 0 decap_w0
xfeed_3703 1 0 decap_w0
xfeed_3702 1 0 decap_w0
xfeed_3701 1 0 decap_w0
xfeed_3700 1 0 decap_w0
xfeed_31599 1 0 decap_w0
xfeed_31598 1 0 decap_w0
xfeed_31597 1 0 decap_w0
xfeed_31596 1 0 decap_w0
xfeed_31595 1 0 decap_w0
xfeed_31594 1 0 decap_w0
xfeed_31593 1 0 decap_w0
xfeed_31592 1 0 decap_w0
xfeed_31591 1 0 decap_w0
xfeed_31590 1 0 decap_w0
xfeed_26209 1 0 decap_w0
xfeed_26208 1 0 decap_w0
xfeed_26207 1 0 decap_w0
xfeed_26206 1 0 decap_w0
xfeed_26205 1 0 decap_w0
xfeed_26204 1 0 decap_w0
xfeed_26203 1 0 decap_w0
xfeed_26202 1 0 decap_w0
xfeed_26201 1 0 decap_w0
xfeed_26200 1 0 decap_w0
xfeed_25599 1 0 decap_w0
xfeed_25598 1 0 decap_w0
xfeed_25597 1 0 decap_w0
xfeed_25596 1 0 decap_w0
xfeed_25595 1 0 decap_w0
xfeed_25594 1 0 decap_w0
xfeed_25593 1 0 decap_w0
xfeed_25592 1 0 decap_w0
xfeed_25591 1 0 decap_w0
xfeed_25590 1 0 decap_w0
xfeed_21289 1 0 decap_w0
xfeed_21288 1 0 decap_w0
xfeed_21287 1 0 decap_w0
xfeed_21286 1 0 decap_w0
xfeed_21285 1 0 decap_w0
xfeed_21284 1 0 decap_w0
xfeed_21283 1 0 decap_w0
xfeed_21282 1 0 decap_w0
xfeed_21281 1 0 decap_w0
xfeed_21280 1 0 decap_w0
xfeed_20759 1 0 decap_w0
xfeed_20758 1 0 decap_w0
xfeed_20757 1 0 decap_w0
xfeed_20756 1 0 decap_w0
xfeed_20755 1 0 decap_w0
xfeed_20754 1 0 decap_w0
xfeed_20753 1 0 decap_w0
xfeed_20752 1 0 decap_w0
xfeed_20751 1 0 decap_w0
xfeed_20750 1 0 decap_w0
xfeed_19594 1 0 decap_w0
xfeed_19593 1 0 decap_w0
xfeed_19592 1 0 decap_w0
xfeed_19591 1 0 decap_w0
xfeed_19590 1 0 decap_w0
xfeed_15289 1 0 decap_w0
xfeed_15288 1 0 decap_w0
xfeed_15287 1 0 decap_w0
xfeed_15286 1 0 decap_w0
xfeed_15285 1 0 decap_w0
xfeed_15284 1 0 decap_w0
xfeed_15283 1 0 decap_w0
xfeed_15282 1 0 decap_w0
xfeed_15281 1 0 decap_w0
xfeed_15280 1 0 decap_w0
xfeed_14755 1 0 decap_w0
xfeed_14754 1 0 decap_w0
xfeed_14753 1 0 decap_w0
xfeed_14752 1 0 decap_w0
xfeed_14751 1 0 decap_w0
xfeed_14750 1 0 decap_w0
xfeed_10449 1 0 decap_w0
xfeed_10448 1 0 decap_w0
xfeed_10447 1 0 decap_w0
xfeed_10446 1 0 decap_w0
xfeed_10445 1 0 decap_w0
xfeed_10444 1 0 decap_w0
xfeed_10443 1 0 decap_w0
xfeed_10442 1 0 decap_w0
xfeed_10441 1 0 decap_w0
xfeed_10440 1 0 decap_w0
xfeed_30 1 0 decap_w0
xfeed_31 1 0 decap_w0
xfeed_32 1 0 decap_w0
xfeed_33 1 0 decap_w0
xfeed_34 1 0 decap_w0
xfeed_35 1 0 decap_w0
xfeed_36 1 0 decap_w0
xfeed_37 1 0 decap_w0
xfeed_38 1 0 decap_w0
xfeed_39 1 0 decap_w0
xfeed_19599 1 0 decap_w0
xfeed_19598 1 0 decap_w0
xfeed_19597 1 0 decap_w0
xfeed_19596 1 0 decap_w0
xfeed_19595 1 0 decap_w0
xfeed_14759 1 0 decap_w0
xfeed_14758 1 0 decap_w0
xfeed_14757 1 0 decap_w0
xfeed_14756 1 0 decap_w0
xfeed_9089 1 0 decap_w0
xfeed_9088 1 0 decap_w0
xfeed_9087 1 0 decap_w0
xfeed_9086 1 0 decap_w0
xfeed_9085 1 0 decap_w0
xfeed_9084 1 0 decap_w0
xfeed_9083 1 0 decap_w0
xfeed_9082 1 0 decap_w0
xfeed_9081 1 0 decap_w0
xfeed_9080 1 0 decap_w0
xfeed_8559 1 0 decap_w0
xfeed_8558 1 0 decap_w0
xfeed_8557 1 0 decap_w0
xfeed_8556 1 0 decap_w0
xfeed_8555 1 0 decap_w0
xfeed_8554 1 0 decap_w0
xfeed_8553 1 0 decap_w0
xfeed_8552 1 0 decap_w0
xfeed_8551 1 0 decap_w0
xfeed_8550 1 0 decap_w0
xfeed_4249 1 0 decap_w0
xfeed_4248 1 0 decap_w0
xfeed_4247 1 0 decap_w0
xfeed_4246 1 0 decap_w0
xfeed_4245 1 0 decap_w0
xfeed_4244 1 0 decap_w0
xfeed_4243 1 0 decap_w0
xfeed_4242 1 0 decap_w0
xfeed_4241 1 0 decap_w0
xfeed_4240 1 0 decap_w0
xfeed_3719 1 0 decap_w0
xfeed_3718 1 0 decap_w0
xfeed_3717 1 0 decap_w0
xfeed_3716 1 0 decap_w0
xfeed_3715 1 0 decap_w0
xfeed_3714 1 0 decap_w0
xfeed_3713 1 0 decap_w0
xfeed_3712 1 0 decap_w0
xfeed_3711 1 0 decap_w0
xfeed_3710 1 0 decap_w0
xfeed_26219 1 0 decap_w0
xfeed_26218 1 0 decap_w0
xfeed_26217 1 0 decap_w0
xfeed_26216 1 0 decap_w0
xfeed_26215 1 0 decap_w0
xfeed_26214 1 0 decap_w0
xfeed_26213 1 0 decap_w0
xfeed_26212 1 0 decap_w0
xfeed_26211 1 0 decap_w0
xfeed_26210 1 0 decap_w0
xfeed_21299 1 0 decap_w0
xfeed_21298 1 0 decap_w0
xfeed_21297 1 0 decap_w0
xfeed_21296 1 0 decap_w0
xfeed_21295 1 0 decap_w0
xfeed_21294 1 0 decap_w0
xfeed_21293 1 0 decap_w0
xfeed_21292 1 0 decap_w0
xfeed_21291 1 0 decap_w0
xfeed_21290 1 0 decap_w0
xfeed_20769 1 0 decap_w0
xfeed_20768 1 0 decap_w0
xfeed_20767 1 0 decap_w0
xfeed_20766 1 0 decap_w0
xfeed_20765 1 0 decap_w0
xfeed_20764 1 0 decap_w0
xfeed_20763 1 0 decap_w0
xfeed_20762 1 0 decap_w0
xfeed_20761 1 0 decap_w0
xfeed_20760 1 0 decap_w0
xfeed_15299 1 0 decap_w0
xfeed_15298 1 0 decap_w0
xfeed_15297 1 0 decap_w0
xfeed_15296 1 0 decap_w0
xfeed_15295 1 0 decap_w0
xfeed_15294 1 0 decap_w0
xfeed_15293 1 0 decap_w0
xfeed_15292 1 0 decap_w0
xfeed_15291 1 0 decap_w0
xfeed_15290 1 0 decap_w0
xfeed_14762 1 0 decap_w0
xfeed_14761 1 0 decap_w0
xfeed_14760 1 0 decap_w0
xfeed_10459 1 0 decap_w0
xfeed_10458 1 0 decap_w0
xfeed_10457 1 0 decap_w0
xfeed_10456 1 0 decap_w0
xfeed_10455 1 0 decap_w0
xfeed_10454 1 0 decap_w0
xfeed_10453 1 0 decap_w0
xfeed_10452 1 0 decap_w0
xfeed_10451 1 0 decap_w0
xfeed_10450 1 0 decap_w0
xfeed_40 1 0 decap_w0
xfeed_41 1 0 decap_w0
xfeed_42 1 0 decap_w0
xfeed_43 1 0 decap_w0
xfeed_44 1 0 decap_w0
xfeed_45 1 0 decap_w0
xfeed_46 1 0 decap_w0
xfeed_14769 1 0 decap_w0
xfeed_14768 1 0 decap_w0
xfeed_14767 1 0 decap_w0
xfeed_14766 1 0 decap_w0
xfeed_14765 1 0 decap_w0
xfeed_14764 1 0 decap_w0
xfeed_14763 1 0 decap_w0
xfeed_9099 1 0 decap_w0
xfeed_9098 1 0 decap_w0
xfeed_9097 1 0 decap_w0
xfeed_9096 1 0 decap_w0
xfeed_9095 1 0 decap_w0
xfeed_9094 1 0 decap_w0
xfeed_9093 1 0 decap_w0
xfeed_9092 1 0 decap_w0
xfeed_9091 1 0 decap_w0
xfeed_9090 1 0 decap_w0
xfeed_8569 1 0 decap_w0
xfeed_8568 1 0 decap_w0
xfeed_8567 1 0 decap_w0
xfeed_8566 1 0 decap_w0
xfeed_8565 1 0 decap_w0
xfeed_8564 1 0 decap_w0
xfeed_8563 1 0 decap_w0
xfeed_8562 1 0 decap_w0
xfeed_8561 1 0 decap_w0
xfeed_8560 1 0 decap_w0
xfeed_4259 1 0 decap_w0
xfeed_4258 1 0 decap_w0
xfeed_4257 1 0 decap_w0
xfeed_4256 1 0 decap_w0
xfeed_4255 1 0 decap_w0
xfeed_4254 1 0 decap_w0
xfeed_4253 1 0 decap_w0
xfeed_4252 1 0 decap_w0
xfeed_4251 1 0 decap_w0
xfeed_4250 1 0 decap_w0
xfeed_3729 1 0 decap_w0
xfeed_3728 1 0 decap_w0
xfeed_3727 1 0 decap_w0
xfeed_3726 1 0 decap_w0
xfeed_3725 1 0 decap_w0
xfeed_3724 1 0 decap_w0
xfeed_3723 1 0 decap_w0
xfeed_3722 1 0 decap_w0
xfeed_3721 1 0 decap_w0
xfeed_3720 1 0 decap_w0
xfeed_47 1 0 decap_w0
xfeed_48 1 0 decap_w0
xfeed_49 1 0 decap_w0
xfeed_26229 1 0 decap_w0
xfeed_26228 1 0 decap_w0
xfeed_26227 1 0 decap_w0
xfeed_26226 1 0 decap_w0
xfeed_26225 1 0 decap_w0
xfeed_26224 1 0 decap_w0
xfeed_26223 1 0 decap_w0
xfeed_26222 1 0 decap_w0
xfeed_26221 1 0 decap_w0
xfeed_26220 1 0 decap_w0
xfeed_20779 1 0 decap_w0
xfeed_20778 1 0 decap_w0
xfeed_20777 1 0 decap_w0
xfeed_20776 1 0 decap_w0
xfeed_20775 1 0 decap_w0
xfeed_20774 1 0 decap_w0
xfeed_20773 1 0 decap_w0
xfeed_20772 1 0 decap_w0
xfeed_20771 1 0 decap_w0
xfeed_20770 1 0 decap_w0
xfeed_10469 1 0 decap_w0
xfeed_10468 1 0 decap_w0
xfeed_10467 1 0 decap_w0
xfeed_10466 1 0 decap_w0
xfeed_10465 1 0 decap_w0
xfeed_10464 1 0 decap_w0
xfeed_10463 1 0 decap_w0
xfeed_10462 1 0 decap_w0
xfeed_10461 1 0 decap_w0
xfeed_10460 1 0 decap_w0
xfeed_50 1 0 decap_w0
xfeed_51 1 0 decap_w0
xfeed_52 1 0 decap_w0
xfeed_53 1 0 decap_w0
xfeed_31703 1 0 decap_w0
xfeed_31702 1 0 decap_w0
xfeed_31701 1 0 decap_w0
xfeed_31700 1 0 decap_w0
xfeed_14779 1 0 decap_w0
xfeed_14778 1 0 decap_w0
xfeed_14777 1 0 decap_w0
xfeed_14776 1 0 decap_w0
xfeed_14775 1 0 decap_w0
xfeed_14774 1 0 decap_w0
xfeed_14773 1 0 decap_w0
xfeed_14772 1 0 decap_w0
xfeed_14771 1 0 decap_w0
xfeed_14770 1 0 decap_w0
xfeed_8579 1 0 decap_w0
xfeed_8578 1 0 decap_w0
xfeed_8577 1 0 decap_w0
xfeed_8576 1 0 decap_w0
xfeed_8575 1 0 decap_w0
xfeed_8574 1 0 decap_w0
xfeed_8573 1 0 decap_w0
xfeed_8572 1 0 decap_w0
xfeed_8571 1 0 decap_w0
xfeed_8570 1 0 decap_w0
xfeed_4269 1 0 decap_w0
xfeed_4268 1 0 decap_w0
xfeed_4267 1 0 decap_w0
xfeed_4266 1 0 decap_w0
xfeed_4265 1 0 decap_w0
xfeed_4264 1 0 decap_w0
xfeed_4263 1 0 decap_w0
xfeed_4262 1 0 decap_w0
xfeed_4261 1 0 decap_w0
xfeed_4260 1 0 decap_w0
xfeed_3739 1 0 decap_w0
xfeed_3738 1 0 decap_w0
xfeed_3737 1 0 decap_w0
xfeed_3736 1 0 decap_w0
xfeed_3735 1 0 decap_w0
xfeed_3734 1 0 decap_w0
xfeed_3733 1 0 decap_w0
xfeed_3732 1 0 decap_w0
xfeed_3731 1 0 decap_w0
xfeed_3730 1 0 decap_w0
xfeed_54 1 0 decap_w0
xfeed_55 1 0 decap_w0
xfeed_56 1 0 decap_w0
xfeed_57 1 0 decap_w0
xfeed_58 1 0 decap_w0
xfeed_59 1 0 decap_w0
xfeed_31709 1 0 decap_w0
xfeed_31708 1 0 decap_w0
xfeed_31707 1 0 decap_w0
xfeed_31706 1 0 decap_w0
xfeed_31705 1 0 decap_w0
xfeed_31704 1 0 decap_w0
xfeed_26239 1 0 decap_w0
xfeed_26238 1 0 decap_w0
xfeed_26237 1 0 decap_w0
xfeed_26236 1 0 decap_w0
xfeed_26235 1 0 decap_w0
xfeed_26234 1 0 decap_w0
xfeed_26233 1 0 decap_w0
xfeed_26232 1 0 decap_w0
xfeed_26231 1 0 decap_w0
xfeed_26230 1 0 decap_w0
xfeed_25709 1 0 decap_w0
xfeed_25708 1 0 decap_w0
xfeed_25707 1 0 decap_w0
xfeed_25706 1 0 decap_w0
xfeed_25705 1 0 decap_w0
xfeed_25704 1 0 decap_w0
xfeed_25703 1 0 decap_w0
xfeed_25702 1 0 decap_w0
xfeed_25701 1 0 decap_w0
xfeed_25700 1 0 decap_w0
xfeed_20789 1 0 decap_w0
xfeed_20788 1 0 decap_w0
xfeed_20787 1 0 decap_w0
xfeed_20786 1 0 decap_w0
xfeed_20785 1 0 decap_w0
xfeed_20784 1 0 decap_w0
xfeed_20783 1 0 decap_w0
xfeed_20782 1 0 decap_w0
xfeed_20781 1 0 decap_w0
xfeed_20780 1 0 decap_w0
xfeed_19709 1 0 decap_w0
xfeed_19708 1 0 decap_w0
xfeed_19707 1 0 decap_w0
xfeed_19706 1 0 decap_w0
xfeed_19705 1 0 decap_w0
xfeed_19704 1 0 decap_w0
xfeed_19703 1 0 decap_w0
xfeed_19702 1 0 decap_w0
xfeed_19701 1 0 decap_w0
xfeed_19700 1 0 decap_w0
xfeed_10476 1 0 decap_w0
xfeed_10475 1 0 decap_w0
xfeed_10474 1 0 decap_w0
xfeed_10473 1 0 decap_w0
xfeed_10472 1 0 decap_w0
xfeed_10471 1 0 decap_w0
xfeed_10470 1 0 decap_w0
xfeed_60 1 0 decap_w0
xfeed_31710 1 0 decap_w0
xfeed_14789 1 0 decap_w0
xfeed_14788 1 0 decap_w0
xfeed_14787 1 0 decap_w0
xfeed_14786 1 0 decap_w0
xfeed_14785 1 0 decap_w0
xfeed_14784 1 0 decap_w0
xfeed_14783 1 0 decap_w0
xfeed_14782 1 0 decap_w0
xfeed_14781 1 0 decap_w0
xfeed_14780 1 0 decap_w0
xfeed_10479 1 0 decap_w0
xfeed_10478 1 0 decap_w0
xfeed_10477 1 0 decap_w0
xfeed_8589 1 0 decap_w0
xfeed_8588 1 0 decap_w0
xfeed_8587 1 0 decap_w0
xfeed_8586 1 0 decap_w0
xfeed_8585 1 0 decap_w0
xfeed_8584 1 0 decap_w0
xfeed_8583 1 0 decap_w0
xfeed_8582 1 0 decap_w0
xfeed_8581 1 0 decap_w0
xfeed_8580 1 0 decap_w0
xfeed_4279 1 0 decap_w0
xfeed_4278 1 0 decap_w0
xfeed_4277 1 0 decap_w0
xfeed_4276 1 0 decap_w0
xfeed_4275 1 0 decap_w0
xfeed_4274 1 0 decap_w0
xfeed_4273 1 0 decap_w0
xfeed_4272 1 0 decap_w0
xfeed_4271 1 0 decap_w0
xfeed_4270 1 0 decap_w0
xfeed_3749 1 0 decap_w0
xfeed_3748 1 0 decap_w0
xfeed_3747 1 0 decap_w0
xfeed_3746 1 0 decap_w0
xfeed_3745 1 0 decap_w0
xfeed_3744 1 0 decap_w0
xfeed_3743 1 0 decap_w0
xfeed_3742 1 0 decap_w0
xfeed_3741 1 0 decap_w0
xfeed_3740 1 0 decap_w0
xfeed_61 1 0 decap_w0
xfeed_62 1 0 decap_w0
xfeed_63 1 0 decap_w0
xfeed_64 1 0 decap_w0
xfeed_65 1 0 decap_w0
xfeed_66 1 0 decap_w0
xfeed_67 1 0 decap_w0
xfeed_68 1 0 decap_w0
xfeed_69 1 0 decap_w0
xfeed_31719 1 0 decap_w0
xfeed_31718 1 0 decap_w0
xfeed_31717 1 0 decap_w0
xfeed_31716 1 0 decap_w0
xfeed_31715 1 0 decap_w0
xfeed_31714 1 0 decap_w0
xfeed_31713 1 0 decap_w0
xfeed_31712 1 0 decap_w0
xfeed_31711 1 0 decap_w0
xfeed_26249 1 0 decap_w0
xfeed_26248 1 0 decap_w0
xfeed_26247 1 0 decap_w0
xfeed_26246 1 0 decap_w0
xfeed_26245 1 0 decap_w0
xfeed_26244 1 0 decap_w0
xfeed_26243 1 0 decap_w0
xfeed_26242 1 0 decap_w0
xfeed_26241 1 0 decap_w0
xfeed_26240 1 0 decap_w0
xfeed_25719 1 0 decap_w0
xfeed_25718 1 0 decap_w0
xfeed_25717 1 0 decap_w0
xfeed_25716 1 0 decap_w0
xfeed_25715 1 0 decap_w0
xfeed_25714 1 0 decap_w0
xfeed_25713 1 0 decap_w0
xfeed_25712 1 0 decap_w0
xfeed_25711 1 0 decap_w0
xfeed_25710 1 0 decap_w0
xfeed_21409 1 0 decap_w0
xfeed_21408 1 0 decap_w0
xfeed_21407 1 0 decap_w0
xfeed_21406 1 0 decap_w0
xfeed_21405 1 0 decap_w0
xfeed_21404 1 0 decap_w0
xfeed_21403 1 0 decap_w0
xfeed_21402 1 0 decap_w0
xfeed_21401 1 0 decap_w0
xfeed_21400 1 0 decap_w0
xfeed_20799 1 0 decap_w0
xfeed_20798 1 0 decap_w0
xfeed_20797 1 0 decap_w0
xfeed_20796 1 0 decap_w0
xfeed_20795 1 0 decap_w0
xfeed_20794 1 0 decap_w0
xfeed_20793 1 0 decap_w0
xfeed_20792 1 0 decap_w0
xfeed_20791 1 0 decap_w0
xfeed_20790 1 0 decap_w0
xfeed_19719 1 0 decap_w0
xfeed_19718 1 0 decap_w0
xfeed_19717 1 0 decap_w0
xfeed_19716 1 0 decap_w0
xfeed_19715 1 0 decap_w0
xfeed_19714 1 0 decap_w0
xfeed_19713 1 0 decap_w0
xfeed_19712 1 0 decap_w0
xfeed_19711 1 0 decap_w0
xfeed_19710 1 0 decap_w0
xfeed_15409 1 0 decap_w0
xfeed_15408 1 0 decap_w0
xfeed_15407 1 0 decap_w0
xfeed_15406 1 0 decap_w0
xfeed_15405 1 0 decap_w0
xfeed_15404 1 0 decap_w0
xfeed_15403 1 0 decap_w0
xfeed_15402 1 0 decap_w0
xfeed_15401 1 0 decap_w0
xfeed_15400 1 0 decap_w0
xfeed_10483 1 0 decap_w0
xfeed_10482 1 0 decap_w0
xfeed_10481 1 0 decap_w0
xfeed_10480 1 0 decap_w0
xfeed_14799 1 0 decap_w0
xfeed_14798 1 0 decap_w0
xfeed_14797 1 0 decap_w0
xfeed_14796 1 0 decap_w0
xfeed_14795 1 0 decap_w0
xfeed_14794 1 0 decap_w0
xfeed_14793 1 0 decap_w0
xfeed_14792 1 0 decap_w0
xfeed_14791 1 0 decap_w0
xfeed_14790 1 0 decap_w0
xfeed_10489 1 0 decap_w0
xfeed_10488 1 0 decap_w0
xfeed_10487 1 0 decap_w0
xfeed_10486 1 0 decap_w0
xfeed_10485 1 0 decap_w0
xfeed_10484 1 0 decap_w0
xfeed_9209 1 0 decap_w0
xfeed_9208 1 0 decap_w0
xfeed_9207 1 0 decap_w0
xfeed_9206 1 0 decap_w0
xfeed_9205 1 0 decap_w0
xfeed_9204 1 0 decap_w0
xfeed_9203 1 0 decap_w0
xfeed_9202 1 0 decap_w0
xfeed_9201 1 0 decap_w0
xfeed_9200 1 0 decap_w0
xfeed_8599 1 0 decap_w0
xfeed_8598 1 0 decap_w0
xfeed_8597 1 0 decap_w0
xfeed_8596 1 0 decap_w0
xfeed_8595 1 0 decap_w0
xfeed_8594 1 0 decap_w0
xfeed_8593 1 0 decap_w0
xfeed_8592 1 0 decap_w0
xfeed_8591 1 0 decap_w0
xfeed_8590 1 0 decap_w0
xfeed_4289 1 0 decap_w0
xfeed_4288 1 0 decap_w0
xfeed_4287 1 0 decap_w0
xfeed_4286 1 0 decap_w0
xfeed_4285 1 0 decap_w0
xfeed_4284 1 0 decap_w0
xfeed_4283 1 0 decap_w0
xfeed_4282 1 0 decap_w0
xfeed_4281 1 0 decap_w0
xfeed_4280 1 0 decap_w0
xfeed_3759 1 0 decap_w0
xfeed_3758 1 0 decap_w0
xfeed_3757 1 0 decap_w0
xfeed_3756 1 0 decap_w0
xfeed_3755 1 0 decap_w0
xfeed_3754 1 0 decap_w0
xfeed_3753 1 0 decap_w0
xfeed_3752 1 0 decap_w0
xfeed_3751 1 0 decap_w0
xfeed_3750 1 0 decap_w0
xfeed_70 1 0 decap_w0
xfeed_71 1 0 decap_w0
xfeed_72 1 0 decap_w0
xfeed_73 1 0 decap_w0
xfeed_74 1 0 decap_w0
xfeed_75 1 0 decap_w0
xfeed_76 1 0 decap_w0
xfeed_77 1 0 decap_w0
xfeed_78 1 0 decap_w0
xfeed_79 1 0 decap_w0
xfeed_31729 1 0 decap_w0
xfeed_31728 1 0 decap_w0
xfeed_31727 1 0 decap_w0
xfeed_31726 1 0 decap_w0
xfeed_31725 1 0 decap_w0
xfeed_31724 1 0 decap_w0
xfeed_31723 1 0 decap_w0
xfeed_31722 1 0 decap_w0
xfeed_31721 1 0 decap_w0
xfeed_31720 1 0 decap_w0
xfeed_26259 1 0 decap_w0
xfeed_26258 1 0 decap_w0
xfeed_26257 1 0 decap_w0
xfeed_26256 1 0 decap_w0
xfeed_26255 1 0 decap_w0
xfeed_26254 1 0 decap_w0
xfeed_26253 1 0 decap_w0
xfeed_26252 1 0 decap_w0
xfeed_26251 1 0 decap_w0
xfeed_26250 1 0 decap_w0
xfeed_25729 1 0 decap_w0
xfeed_25728 1 0 decap_w0
xfeed_25727 1 0 decap_w0
xfeed_25726 1 0 decap_w0
xfeed_25725 1 0 decap_w0
xfeed_25724 1 0 decap_w0
xfeed_25723 1 0 decap_w0
xfeed_25722 1 0 decap_w0
xfeed_25721 1 0 decap_w0
xfeed_25720 1 0 decap_w0
xfeed_21419 1 0 decap_w0
xfeed_21418 1 0 decap_w0
xfeed_21417 1 0 decap_w0
xfeed_21416 1 0 decap_w0
xfeed_21415 1 0 decap_w0
xfeed_21414 1 0 decap_w0
xfeed_21413 1 0 decap_w0
xfeed_21412 1 0 decap_w0
xfeed_21411 1 0 decap_w0
xfeed_21410 1 0 decap_w0
xfeed_19727 1 0 decap_w0
xfeed_19726 1 0 decap_w0
xfeed_19725 1 0 decap_w0
xfeed_19724 1 0 decap_w0
xfeed_19723 1 0 decap_w0
xfeed_19722 1 0 decap_w0
xfeed_19721 1 0 decap_w0
xfeed_19720 1 0 decap_w0
xfeed_15419 1 0 decap_w0
xfeed_15418 1 0 decap_w0
xfeed_15417 1 0 decap_w0
xfeed_15416 1 0 decap_w0
xfeed_15415 1 0 decap_w0
xfeed_15414 1 0 decap_w0
xfeed_15413 1 0 decap_w0
xfeed_15412 1 0 decap_w0
xfeed_15411 1 0 decap_w0
xfeed_15410 1 0 decap_w0
xfeed_11109 1 0 decap_w0
xfeed_11108 1 0 decap_w0
xfeed_11107 1 0 decap_w0
xfeed_11106 1 0 decap_w0
xfeed_11105 1 0 decap_w0
xfeed_11104 1 0 decap_w0
xfeed_11103 1 0 decap_w0
xfeed_11102 1 0 decap_w0
xfeed_11101 1 0 decap_w0
xfeed_11100 1 0 decap_w0
xfeed_10490 1 0 decap_w0
xfeed_19729 1 0 decap_w0
xfeed_19728 1 0 decap_w0
xfeed_10499 1 0 decap_w0
xfeed_10498 1 0 decap_w0
xfeed_10497 1 0 decap_w0
xfeed_10496 1 0 decap_w0
xfeed_10495 1 0 decap_w0
xfeed_10494 1 0 decap_w0
xfeed_10493 1 0 decap_w0
xfeed_10492 1 0 decap_w0
xfeed_10491 1 0 decap_w0
xfeed_9219 1 0 decap_w0
xfeed_9218 1 0 decap_w0
xfeed_9217 1 0 decap_w0
xfeed_9216 1 0 decap_w0
xfeed_9215 1 0 decap_w0
xfeed_9214 1 0 decap_w0
xfeed_9213 1 0 decap_w0
xfeed_9212 1 0 decap_w0
xfeed_9211 1 0 decap_w0
xfeed_9210 1 0 decap_w0
xfeed_4299 1 0 decap_w0
xfeed_4298 1 0 decap_w0
xfeed_4297 1 0 decap_w0
xfeed_4296 1 0 decap_w0
xfeed_4295 1 0 decap_w0
xfeed_4294 1 0 decap_w0
xfeed_4293 1 0 decap_w0
xfeed_4292 1 0 decap_w0
xfeed_4291 1 0 decap_w0
xfeed_4290 1 0 decap_w0
xfeed_3768 1 0 decap_w0
xfeed_3767 1 0 decap_w0
xfeed_3766 1 0 decap_w0
xfeed_3765 1 0 decap_w0
xfeed_3764 1 0 decap_w0
xfeed_3763 1 0 tie
xfeed_3762 1 0 decap_w0
xfeed_3761 1 0 decap_w0
xfeed_3760 1 0 decap_w0
xfeed_80 1 0 decap_w0
xfeed_81 1 0 decap_w0
xfeed_82 1 0 decap_w0
xfeed_83 1 0 decap_w0
xfeed_84 1 0 decap_w0
xfeed_85 1 0 decap_w0
xfeed_86 1 0 decap_w0
xfeed_87 1 0 decap_w0
xfeed_88 1 0 decap_w0
xfeed_89 1 0 decap_w0
xfeed_31739 1 0 decap_w0
xfeed_31738 1 0 decap_w0
xfeed_31737 1 0 decap_w0
xfeed_31736 1 0 decap_w0
xfeed_31735 1 0 decap_w0
xfeed_31734 1 0 decap_w0
xfeed_31733 1 0 decap_w0
xfeed_31732 1 0 decap_w0
xfeed_31731 1 0 decap_w0
xfeed_31730 1 0 decap_w0
xfeed_26269 1 0 decap_w0
xfeed_26268 1 0 decap_w0
xfeed_26267 1 0 decap_w0
xfeed_26266 1 0 decap_w0
xfeed_26265 1 0 decap_w0
xfeed_26264 1 0 decap_w0
xfeed_26263 1 0 decap_w0
xfeed_26262 1 0 decap_w0
xfeed_26261 1 0 decap_w0
xfeed_26260 1 0 decap_w0
xfeed_25739 1 0 decap_w0
xfeed_25738 1 0 decap_w0
xfeed_25737 1 0 decap_w0
xfeed_25736 1 0 decap_w0
xfeed_25735 1 0 decap_w0
xfeed_25734 1 0 decap_w0
xfeed_25733 1 0 decap_w0
xfeed_25732 1 0 decap_w0
xfeed_25731 1 0 decap_w0
xfeed_25730 1 0 decap_w0
xfeed_21429 1 0 decap_w0
xfeed_21428 1 0 decap_w0
xfeed_21427 1 0 decap_w0
xfeed_21426 1 0 decap_w0
xfeed_21425 1 0 decap_w0
xfeed_21424 1 0 decap_w0
xfeed_21423 1 0 decap_w0
xfeed_21422 1 0 decap_w0
xfeed_21421 1 0 decap_w0
xfeed_21420 1 0 decap_w0
xfeed_19734 1 0 decap_w0
xfeed_19733 1 0 decap_w0
xfeed_19732 1 0 decap_w0
xfeed_19731 1 0 decap_w0
xfeed_19730 1 0 decap_w0
xfeed_15429 1 0 decap_w0
xfeed_15428 1 0 decap_w0
xfeed_15427 1 0 decap_w0
xfeed_15426 1 0 decap_w0
xfeed_15425 1 0 decap_w0
xfeed_15424 1 0 decap_w0
xfeed_15423 1 0 decap_w0
xfeed_15422 1 0 decap_w0
xfeed_15421 1 0 decap_w0
xfeed_15420 1 0 decap_w0
xfeed_11119 1 0 decap_w0
xfeed_11118 1 0 decap_w0
xfeed_11117 1 0 decap_w0
xfeed_11116 1 0 decap_w0
xfeed_11115 1 0 decap_w0
xfeed_11114 1 0 decap_w0
xfeed_11113 1 0 decap_w0
xfeed_11112 1 0 decap_w0
xfeed_11111 1 0 decap_w0
xfeed_11110 1 0 decap_w0
xfeed_3769 1 0 decap_w0
xfeed_19739 1 0 decap_w0
xfeed_19738 1 0 decap_w0
xfeed_19737 1 0 decap_w0
xfeed_19736 1 0 decap_w0
xfeed_19735 1 0 decap_w0
xfeed_9229 1 0 decap_w0
xfeed_9228 1 0 decap_w0
xfeed_9227 1 0 decap_w0
xfeed_9226 1 0 decap_w0
xfeed_9225 1 0 decap_w0
xfeed_9224 1 0 decap_w0
xfeed_9223 1 0 decap_w0
xfeed_9222 1 0 decap_w0
xfeed_9221 1 0 decap_w0
xfeed_9220 1 0 decap_w0
xfeed_3775 1 0 decap_w0
xfeed_3774 1 0 decap_w0
xfeed_3773 1 0 decap_w0
xfeed_3772 1 0 decap_w0
xfeed_3771 1 0 decap_w0
xfeed_3770 1 0 decap_w0
xfeed_90 1 0 decap_w0
xfeed_91 1 0 decap_w0
xfeed_92 1 0 decap_w0
xfeed_93 1 0 decap_w0
xfeed_94 1 0 decap_w0
xfeed_95 1 0 decap_w0
xfeed_96 1 0 decap_w0
xfeed_97 1 0 decap_w0
xfeed_98 1 0 decap_w0
xfeed_99 1 0 decap_w0
xfeed_31749 1 0 decap_w0
xfeed_31748 1 0 decap_w0
xfeed_31747 1 0 decap_w0
xfeed_31746 1 0 decap_w0
xfeed_31745 1 0 decap_w0
xfeed_31744 1 0 decap_w0
xfeed_31743 1 0 decap_w0
xfeed_31742 1 0 decap_w0
xfeed_31741 1 0 decap_w0
xfeed_31740 1 0 decap_w0
xfeed_26279 1 0 decap_w0
xfeed_26278 1 0 decap_w0
xfeed_26277 1 0 decap_w0
xfeed_26276 1 0 decap_w0
xfeed_26275 1 0 decap_w0
xfeed_26274 1 0 decap_w0
xfeed_26273 1 0 decap_w0
xfeed_26272 1 0 decap_w0
xfeed_26271 1 0 decap_w0
xfeed_26270 1 0 decap_w0
xfeed_25749 1 0 decap_w0
xfeed_25748 1 0 decap_w0
xfeed_25747 1 0 decap_w0
xfeed_25746 1 0 decap_w0
xfeed_25745 1 0 decap_w0
xfeed_25744 1 0 decap_w0
xfeed_25743 1 0 decap_w0
xfeed_25742 1 0 decap_w0
xfeed_25741 1 0 decap_w0
xfeed_25740 1 0 decap_w0
xfeed_21439 1 0 decap_w0
xfeed_21438 1 0 decap_w0
xfeed_21437 1 0 decap_w0
xfeed_21436 1 0 decap_w0
xfeed_21435 1 0 decap_w0
xfeed_21434 1 0 decap_w0
xfeed_21433 1 0 decap_w0
xfeed_21432 1 0 decap_w0
xfeed_21431 1 0 decap_w0
xfeed_21430 1 0 decap_w0
xfeed_20909 1 0 decap_w0
xfeed_20908 1 0 decap_w0
xfeed_20907 1 0 decap_w0
xfeed_20906 1 0 decap_w0
xfeed_20905 1 0 decap_w0
xfeed_20904 1 0 decap_w0
xfeed_20903 1 0 decap_w0
xfeed_20902 1 0 decap_w0
xfeed_20901 1 0 decap_w0
xfeed_20900 1 0 decap_w0
xfeed_19741 1 0 decap_w0
xfeed_19740 1 0 decap_w0
xfeed_15439 1 0 decap_w0
xfeed_15438 1 0 decap_w0
xfeed_15437 1 0 decap_w0
xfeed_15436 1 0 decap_w0
xfeed_15435 1 0 decap_w0
xfeed_15434 1 0 decap_w0
xfeed_15433 1 0 decap_w0
xfeed_15432 1 0 decap_w0
xfeed_15431 1 0 decap_w0
xfeed_15430 1 0 decap_w0
xfeed_14902 1 0 decap_w0
xfeed_14901 1 0 decap_w0
xfeed_14900 1 0 decap_w0
xfeed_11129 1 0 decap_w0
xfeed_11128 1 0 decap_w0
xfeed_11127 1 0 decap_w0
xfeed_11126 1 0 decap_w0
xfeed_11125 1 0 decap_w0
xfeed_11124 1 0 decap_w0
xfeed_11123 1 0 decap_w0
xfeed_11122 1 0 decap_w0
xfeed_11121 1 0 decap_w0
xfeed_11120 1 0 decap_w0
xfeed_3779 1 0 decap_w0
xfeed_3778 1 0 decap_w0
xfeed_3777 1 0 decap_w0
xfeed_3776 1 0 decap_w0
xfeed_19749 1 0 tie
xfeed_19748 1 0 decap_w0
xfeed_19747 1 0 decap_w0
xfeed_19746 1 0 decap_w0
xfeed_19745 1 0 decap_w0
xfeed_19744 1 0 decap_w0
xfeed_19743 1 0 decap_w0
xfeed_19742 1 0 decap_w0
xfeed_14909 1 0 decap_w0
xfeed_14908 1 0 decap_w0
xfeed_14907 1 0 decap_w0
xfeed_14906 1 0 decap_w0
xfeed_14905 1 0 decap_w0
xfeed_14904 1 0 decap_w0
xfeed_14903 1 0 decap_w0
xfeed_9239 1 0 decap_w0
xfeed_9238 1 0 decap_w0
xfeed_9237 1 0 decap_w0
xfeed_9236 1 0 decap_w0
xfeed_9235 1 0 decap_w0
xfeed_9234 1 0 decap_w0
xfeed_9233 1 0 decap_w0
xfeed_9232 1 0 decap_w0
xfeed_9231 1 0 decap_w0
xfeed_9230 1 0 decap_w0
xfeed_8709 1 0 decap_w0
xfeed_8708 1 0 decap_w0
xfeed_8707 1 0 decap_w0
xfeed_8706 1 0 decap_w0
xfeed_8705 1 0 decap_w0
xfeed_8704 1 0 decap_w0
xfeed_8703 1 0 decap_w0
xfeed_8702 1 0 decap_w0
xfeed_8701 1 0 decap_w0
xfeed_8700 1 0 decap_w0
xfeed_3782 1 0 decap_w0
xfeed_3781 1 0 decap_w0
xfeed_3780 1 0 decap_w0
xfeed_31759 1 0 decap_w0
xfeed_31758 1 0 decap_w0
xfeed_31757 1 0 decap_w0
xfeed_31756 1 0 decap_w0
xfeed_31755 1 0 decap_w0
xfeed_31754 1 0 decap_w0
xfeed_31753 1 0 decap_w0
xfeed_31752 1 0 decap_w0
xfeed_31751 1 0 decap_w0
xfeed_31750 1 0 decap_w0
xfeed_26289 1 0 decap_w0
xfeed_26288 1 0 decap_w0
xfeed_26287 1 0 decap_w0
xfeed_26286 1 0 decap_w0
xfeed_26285 1 0 decap_w0
xfeed_26284 1 0 decap_w0
xfeed_26283 1 0 decap_w0
xfeed_26282 1 0 decap_w0
xfeed_26281 1 0 decap_w0
xfeed_26280 1 0 decap_w0
xfeed_25759 1 0 decap_w0
xfeed_25758 1 0 decap_w0
xfeed_25757 1 0 decap_w0
xfeed_25756 1 0 decap_w0
xfeed_25755 1 0 decap_w0
xfeed_25754 1 0 decap_w0
xfeed_25753 1 0 decap_w0
xfeed_25752 1 0 decap_w0
xfeed_25751 1 0 decap_w0
xfeed_25750 1 0 decap_w0
xfeed_21449 1 0 decap_w0
xfeed_21448 1 0 decap_w0
xfeed_21447 1 0 decap_w0
xfeed_21446 1 0 decap_w0
xfeed_21445 1 0 decap_w0
xfeed_21444 1 0 decap_w0
xfeed_21443 1 0 decap_w0
xfeed_21442 1 0 decap_w0
xfeed_21441 1 0 decap_w0
xfeed_21440 1 0 decap_w0
xfeed_20919 1 0 decap_w0
xfeed_20918 1 0 decap_w0
xfeed_20917 1 0 decap_w0
xfeed_20916 1 0 decap_w0
xfeed_20915 1 0 decap_w0
xfeed_20914 1 0 decap_w0
xfeed_20913 1 0 decap_w0
xfeed_20912 1 0 decap_w0
xfeed_20911 1 0 decap_w0
xfeed_20910 1 0 decap_w0
xfeed_15448 1 0 decap_w0
xfeed_15447 1 0 decap_w0
xfeed_15446 1 0 decap_w0
xfeed_15445 1 0 decap_w0
xfeed_15444 1 0 decap_w0
xfeed_15443 1 0 decap_w0
xfeed_15442 1 0 decap_w0
xfeed_15441 1 0 decap_w0
xfeed_15440 1 0 decap_w0
xfeed_11139 1 0 decap_w0
xfeed_11138 1 0 decap_w0
xfeed_11137 1 0 decap_w0
xfeed_11136 1 0 decap_w0
xfeed_11135 1 0 decap_w0
xfeed_11134 1 0 decap_w0
xfeed_11133 1 0 decap_w0
xfeed_11132 1 0 decap_w0
xfeed_11131 1 0 decap_w0
xfeed_11130 1 0 decap_w0
xfeed_10609 1 0 decap_w0
xfeed_10608 1 0 decap_w0
xfeed_10607 1 0 decap_w0
xfeed_10606 1 0 decap_w0
xfeed_10605 1 0 decap_w0
xfeed_10604 1 0 decap_w0
xfeed_10603 1 0 decap_w0
xfeed_10602 1 0 decap_w0
xfeed_10601 1 0 decap_w0
xfeed_10600 1 0 decap_w0
xfeed_3789 1 0 decap_w0
xfeed_3788 1 0 decap_w0
xfeed_3787 1 0 decap_w0
xfeed_3786 1 0 decap_w0
xfeed_3785 1 0 decap_w0
xfeed_3784 1 0 decap_w0
xfeed_3783 1 0 decap_w0
xfeed_19759 1 0 decap_w0
xfeed_19758 1 0 decap_w0
xfeed_19757 1 0 decap_w0
xfeed_19756 1 0 decap_w0
xfeed_19755 1 0 decap_w0
xfeed_19754 1 0 decap_w0
xfeed_19753 1 0 decap_w0
xfeed_19752 1 0 decap_w0
xfeed_19751 1 0 decap_w0
xfeed_19750 1 0 decap_w0
xfeed_15449 1 0 decap_w0
xfeed_14919 1 0 decap_w0
xfeed_14918 1 0 decap_w0
xfeed_14917 1 0 decap_w0
xfeed_14916 1 0 decap_w0
xfeed_14915 1 0 decap_w0
xfeed_14914 1 0 decap_w0
xfeed_14913 1 0 decap_w0
xfeed_14912 1 0 decap_w0
xfeed_14911 1 0 decap_w0
xfeed_14910 1 0 decap_w0
xfeed_9249 1 0 decap_w0
xfeed_9248 1 0 decap_w0
xfeed_9247 1 0 decap_w0
xfeed_9246 1 0 decap_w0
xfeed_9245 1 0 decap_w0
xfeed_9244 1 0 decap_w0
xfeed_9243 1 0 decap_w0
xfeed_9242 1 0 decap_w0
xfeed_9241 1 0 decap_w0
xfeed_9240 1 0 decap_w0
xfeed_8719 1 0 decap_w0
xfeed_8718 1 0 decap_w0
xfeed_8717 1 0 decap_w0
xfeed_8716 1 0 decap_w0
xfeed_8715 1 0 decap_w0
xfeed_8714 1 0 decap_w0
xfeed_8713 1 0 decap_w0
xfeed_8712 1 0 decap_w0
xfeed_8711 1 0 decap_w0
xfeed_8710 1 0 decap_w0
xfeed_4409 1 0 decap_w0
xfeed_4408 1 0 decap_w0
xfeed_4407 1 0 decap_w0
xfeed_4406 1 0 decap_w0
xfeed_4405 1 0 decap_w0
xfeed_4404 1 0 decap_w0
xfeed_4403 1 0 decap_w0
xfeed_4402 1 0 decap_w0
xfeed_4401 1 0 decap_w0
xfeed_4400 1 0 decap_w0
xfeed_31769 1 0 decap_w0
xfeed_31768 1 0 decap_w0
xfeed_31767 1 0 decap_w0
xfeed_31766 1 0 decap_w0
xfeed_31765 1 0 decap_w0
xfeed_31764 1 0 decap_w0
xfeed_31763 1 0 decap_w0
xfeed_31762 1 0 decap_w0
xfeed_31761 1 0 decap_w0
xfeed_31760 1 0 decap_w0
xfeed_26299 1 0 decap_w0
xfeed_26298 1 0 decap_w0
xfeed_26297 1 0 decap_w0
xfeed_26296 1 0 decap_w0
xfeed_26295 1 0 decap_w0
xfeed_26294 1 0 decap_w0
xfeed_26293 1 0 decap_w0
xfeed_26292 1 0 decap_w0
xfeed_26291 1 0 decap_w0
xfeed_26290 1 0 decap_w0
xfeed_25769 1 0 decap_w0
xfeed_25768 1 0 decap_w0
xfeed_25767 1 0 decap_w0
xfeed_25766 1 0 decap_w0
xfeed_25765 1 0 decap_w0
xfeed_25764 1 0 decap_w0
xfeed_25763 1 0 decap_w0
xfeed_25762 1 0 decap_w0
xfeed_25761 1 0 decap_w0
xfeed_25760 1 0 decap_w0
xfeed_21459 1 0 decap_w0
xfeed_21458 1 0 decap_w0
xfeed_21457 1 0 decap_w0
xfeed_21456 1 0 decap_w0
xfeed_21455 1 0 decap_w0
xfeed_21454 1 0 decap_w0
xfeed_21453 1 0 decap_w0
xfeed_21452 1 0 decap_w0
xfeed_21451 1 0 decap_w0
xfeed_21450 1 0 decap_w0
xfeed_20929 1 0 decap_w0
xfeed_20928 1 0 decap_w0
xfeed_20927 1 0 decap_w0
xfeed_20926 1 0 decap_w0
xfeed_20925 1 0 decap_w0
xfeed_20924 1 0 decap_w0
xfeed_20923 1 0 decap_w0
xfeed_20922 1 0 decap_w0
xfeed_20921 1 0 decap_w0
xfeed_20920 1 0 decap_w0
xfeed_15455 1 0 decap_w0
xfeed_15454 1 0 decap_w0
xfeed_15453 1 0 decap_w0
xfeed_15452 1 0 decap_w0
xfeed_15451 1 0 decap_w0
xfeed_15450 1 0 decap_w0
xfeed_11149 1 0 decap_w0
xfeed_11148 1 0 decap_w0
xfeed_11147 1 0 decap_w0
xfeed_11146 1 0 decap_w0
xfeed_11145 1 0 decap_w0
xfeed_11144 1 0 decap_w0
xfeed_11143 1 0 decap_w0
xfeed_11142 1 0 decap_w0
xfeed_11141 1 0 decap_w0
xfeed_11140 1 0 decap_w0
xfeed_10616 1 0 decap_w0
xfeed_10615 1 0 decap_w0
xfeed_10614 1 0 decap_w0
xfeed_10613 1 0 decap_w0
xfeed_10612 1 0 decap_w0
xfeed_10611 1 0 decap_w0
xfeed_10610 1 0 decap_w0
xfeed_3799 1 0 decap_w0
xfeed_3798 1 0 decap_w0
xfeed_3797 1 0 decap_w0
xfeed_3796 1 0 decap_w0
xfeed_3795 1 0 decap_w0
xfeed_3794 1 0 decap_w0
xfeed_3793 1 0 decap_w0
xfeed_3792 1 0 decap_w0
xfeed_3791 1 0 decap_w0
xfeed_3790 1 0 decap_w0
xfeed_19769 1 0 decap_w0
xfeed_19768 1 0 decap_w0
xfeed_19767 1 0 decap_w0
xfeed_19766 1 0 decap_w0
xfeed_19765 1 0 decap_w0
xfeed_19764 1 0 decap_w0
xfeed_19763 1 0 decap_w0
xfeed_19762 1 0 decap_w0
xfeed_19761 1 0 decap_w0
xfeed_19760 1 0 decap_w0
xfeed_15459 1 0 decap_w0
xfeed_15458 1 0 decap_w0
xfeed_15457 1 0 decap_w0
xfeed_15456 1 0 decap_w0
xfeed_14929 1 0 decap_w0
xfeed_14928 1 0 decap_w0
xfeed_14927 1 0 decap_w0
xfeed_14926 1 0 decap_w0
xfeed_14925 1 0 decap_w0
xfeed_14924 1 0 decap_w0
xfeed_14923 1 0 decap_w0
xfeed_14922 1 0 decap_w0
xfeed_14921 1 0 decap_w0
xfeed_14920 1 0 decap_w0
xfeed_10619 1 0 decap_w0
xfeed_10618 1 0 decap_w0
xfeed_10617 1 0 decap_w0
xfeed_9259 1 0 decap_w0
xfeed_9258 1 0 decap_w0
xfeed_9257 1 0 decap_w0
xfeed_9256 1 0 decap_w0
xfeed_9255 1 0 decap_w0
xfeed_9254 1 0 decap_w0
xfeed_9253 1 0 decap_w0
xfeed_9252 1 0 decap_w0
xfeed_9251 1 0 decap_w0
xfeed_9250 1 0 decap_w0
xfeed_8729 1 0 decap_w0
xfeed_8728 1 0 decap_w0
xfeed_8727 1 0 decap_w0
xfeed_8726 1 0 decap_w0
xfeed_8725 1 0 decap_w0
xfeed_8724 1 0 decap_w0
xfeed_8723 1 0 decap_w0
xfeed_8722 1 0 decap_w0
xfeed_8721 1 0 decap_w0
xfeed_8720 1 0 decap_w0
xfeed_4419 1 0 decap_w0
xfeed_4418 1 0 decap_w0
xfeed_4417 1 0 decap_w0
xfeed_4416 1 0 decap_w0
xfeed_4415 1 0 decap_w0
xfeed_4414 1 0 decap_w0
xfeed_4413 1 0 decap_w0
xfeed_4412 1 0 decap_w0
xfeed_4411 1 0 decap_w0
xfeed_4410 1 0 decap_w0
xfeed_31779 1 0 decap_w0
xfeed_31778 1 0 decap_w0
xfeed_31777 1 0 decap_w0
xfeed_31776 1 0 decap_w0
xfeed_31775 1 0 decap_w0
xfeed_31774 1 0 decap_w0
xfeed_31773 1 0 decap_w0
xfeed_31772 1 0 decap_w0
xfeed_31771 1 0 decap_w0
xfeed_31770 1 0 decap_w0
xfeed_25779 1 0 decap_w0
xfeed_25778 1 0 decap_w0
xfeed_25777 1 0 decap_w0
xfeed_25776 1 0 decap_w0
xfeed_25775 1 0 decap_w0
xfeed_25774 1 0 decap_w0
xfeed_25773 1 0 decap_w0
xfeed_25772 1 0 decap_w0
xfeed_25771 1 0 decap_w0
xfeed_25770 1 0 decap_w0
xfeed_21469 1 0 decap_w0
xfeed_21468 1 0 decap_w0
xfeed_21467 1 0 decap_w0
xfeed_21466 1 0 decap_w0
xfeed_21465 1 0 decap_w0
xfeed_21464 1 0 decap_w0
xfeed_21463 1 0 decap_w0
xfeed_21462 1 0 decap_w0
xfeed_21461 1 0 decap_w0
xfeed_21460 1 0 decap_w0
xfeed_20939 1 0 decap_w0
xfeed_20938 1 0 decap_w0
xfeed_20937 1 0 decap_w0
xfeed_20936 1 0 decap_w0
xfeed_20935 1 0 decap_w0
xfeed_20934 1 0 decap_w0
xfeed_20933 1 0 decap_w0
xfeed_20932 1 0 decap_w0
xfeed_20931 1 0 decap_w0
xfeed_20930 1 0 decap_w0
xfeed_15462 1 0 decap_w0
xfeed_15461 1 0 decap_w0
xfeed_15460 1 0 decap_w0
xfeed_11159 1 0 decap_w0
xfeed_11158 1 0 decap_w0
xfeed_11157 1 0 decap_w0
xfeed_11156 1 0 decap_w0
xfeed_11155 1 0 decap_w0
xfeed_11154 1 0 decap_w0
xfeed_11153 1 0 decap_w0
xfeed_11152 1 0 decap_w0
xfeed_11151 1 0 decap_w0
xfeed_11150 1 0 decap_w0
xfeed_10623 1 0 decap_w0
xfeed_10622 1 0 decap_w0
xfeed_10621 1 0 decap_w0
xfeed_10620 1 0 decap_w0
xfeed_19779 1 0 decap_w0
xfeed_19778 1 0 decap_w0
xfeed_19777 1 0 decap_w0
xfeed_19776 1 0 decap_w0
xfeed_19775 1 0 decap_w0
xfeed_19774 1 0 decap_w0
xfeed_19773 1 0 decap_w0
xfeed_19772 1 0 decap_w0
xfeed_19771 1 0 decap_w0
xfeed_19770 1 0 decap_w0
xfeed_15469 1 0 decap_w0
xfeed_15468 1 0 decap_w0
xfeed_15467 1 0 decap_w0
xfeed_15466 1 0 decap_w0
xfeed_15465 1 0 decap_w0
xfeed_15464 1 0 decap_w0
xfeed_15463 1 0 decap_w0
xfeed_14939 1 0 decap_w0
xfeed_14938 1 0 decap_w0
xfeed_14937 1 0 decap_w0
xfeed_14936 1 0 decap_w0
xfeed_14935 1 0 decap_w0
xfeed_14934 1 0 decap_w0
xfeed_14933 1 0 decap_w0
xfeed_14932 1 0 decap_w0
xfeed_14931 1 0 decap_w0
xfeed_14930 1 0 decap_w0
xfeed_10629 1 0 decap_w0
xfeed_10628 1 0 decap_w0
xfeed_10627 1 0 decap_w0
xfeed_10626 1 0 decap_w0
xfeed_10625 1 0 decap_w0
xfeed_10624 1 0 decap_w0
xfeed_9269 1 0 decap_w0
xfeed_9268 1 0 decap_w0
xfeed_9267 1 0 decap_w0
xfeed_9266 1 0 decap_w0
xfeed_9265 1 0 decap_w0
xfeed_9264 1 0 decap_w0
xfeed_9263 1 0 decap_w0
xfeed_9262 1 0 decap_w0
xfeed_9261 1 0 decap_w0
xfeed_9260 1 0 decap_w0
xfeed_8739 1 0 decap_w0
xfeed_8738 1 0 decap_w0
xfeed_8737 1 0 decap_w0
xfeed_8736 1 0 decap_w0
xfeed_8735 1 0 decap_w0
xfeed_8734 1 0 decap_w0
xfeed_8733 1 0 decap_w0
xfeed_8732 1 0 decap_w0
xfeed_8731 1 0 decap_w0
xfeed_8730 1 0 decap_w0
xfeed_4429 1 0 decap_w0
xfeed_4428 1 0 decap_w0
xfeed_4427 1 0 decap_w0
xfeed_4426 1 0 decap_w0
xfeed_4425 1 0 decap_w0
xfeed_4424 1 0 decap_w0
xfeed_4423 1 0 decap_w0
xfeed_4422 1 0 decap_w0
xfeed_4421 1 0 decap_w0
xfeed_4420 1 0 decap_w0
xfeed_31789 1 0 decap_w0
xfeed_31788 1 0 decap_w0
xfeed_31787 1 0 decap_w0
xfeed_31786 1 0 decap_w0
xfeed_31785 1 0 decap_w0
xfeed_31784 1 0 decap_w0
xfeed_31783 1 0 decap_w0
xfeed_31782 1 0 decap_w0
xfeed_31781 1 0 decap_w0
xfeed_31780 1 0 decap_w0
xfeed_25789 1 0 decap_w0
xfeed_25788 1 0 decap_w0
xfeed_25787 1 0 decap_w0
xfeed_25786 1 0 decap_w0
xfeed_25785 1 0 decap_w0
xfeed_25784 1 0 decap_w0
xfeed_25783 1 0 decap_w0
xfeed_25782 1 0 decap_w0
xfeed_25781 1 0 decap_w0
xfeed_25780 1 0 decap_w0
xfeed_21479 1 0 decap_w0
xfeed_21478 1 0 decap_w0
xfeed_21477 1 0 decap_w0
xfeed_21476 1 0 decap_w0
xfeed_21475 1 0 decap_w0
xfeed_21474 1 0 decap_w0
xfeed_21473 1 0 decap_w0
xfeed_21472 1 0 decap_w0
xfeed_21471 1 0 decap_w0
xfeed_21470 1 0 decap_w0
xfeed_20949 1 0 decap_w0
xfeed_20948 1 0 decap_w0
xfeed_20947 1 0 decap_w0
xfeed_20946 1 0 decap_w0
xfeed_20945 1 0 decap_w0
xfeed_20944 1 0 decap_w0
xfeed_20943 1 0 decap_w0
xfeed_20942 1 0 decap_w0
xfeed_20941 1 0 decap_w0
xfeed_20940 1 0 decap_w0
xfeed_11169 1 0 decap_w0
xfeed_11168 1 0 decap_w0
xfeed_11167 1 0 decap_w0
xfeed_11166 1 0 decap_w0
xfeed_11165 1 0 decap_w0
xfeed_11164 1 0 decap_w0
xfeed_11163 1 0 decap_w0
xfeed_11162 1 0 decap_w0
xfeed_11161 1 0 decap_w0
xfeed_11160 1 0 decap_w0
xfeed_10630 1 0 decap_w0
xfeed_19789 1 0 decap_w0
xfeed_19788 1 0 decap_w0
xfeed_19787 1 0 decap_w0
xfeed_19786 1 0 decap_w0
xfeed_19785 1 0 decap_w0
xfeed_19784 1 0 decap_w0
xfeed_19783 1 0 decap_w0
xfeed_19782 1 0 decap_w0
xfeed_19781 1 0 decap_w0
xfeed_19780 1 0 decap_w0
xfeed_15479 1 0 decap_w0
xfeed_15478 1 0 decap_w0
xfeed_15477 1 0 decap_w0
xfeed_15476 1 0 decap_w0
xfeed_15475 1 0 decap_w0
xfeed_15474 1 0 decap_w0
xfeed_15473 1 0 decap_w0
xfeed_15472 1 0 decap_w0
xfeed_15471 1 0 decap_w0
xfeed_15470 1 0 decap_w0
xfeed_14949 1 0 decap_w0
xfeed_14948 1 0 decap_w0
xfeed_14947 1 0 decap_w0
xfeed_14946 1 0 decap_w0
xfeed_14945 1 0 decap_w0
xfeed_14944 1 0 decap_w0
xfeed_14943 1 0 decap_w0
xfeed_14942 1 0 decap_w0
xfeed_14941 1 0 decap_w0
xfeed_14940 1 0 decap_w0
xfeed_10639 1 0 decap_w0
xfeed_10638 1 0 decap_w0
xfeed_10637 1 0 decap_w0
xfeed_10636 1 0 decap_w0
xfeed_10635 1 0 decap_w0
xfeed_10634 1 0 decap_w0
xfeed_10633 1 0 decap_w0
xfeed_10632 1 0 decap_w0
xfeed_10631 1 0 decap_w0
xfeed_9279 1 0 decap_w0
xfeed_9278 1 0 decap_w0
xfeed_9277 1 0 decap_w0
xfeed_9276 1 0 decap_w0
xfeed_9275 1 0 decap_w0
xfeed_9274 1 0 decap_w0
xfeed_9273 1 0 decap_w0
xfeed_9272 1 0 decap_w0
xfeed_9271 1 0 decap_w0
xfeed_9270 1 0 decap_w0
xfeed_8747 1 0 decap_w0
xfeed_8746 1 0 decap_w0
xfeed_8745 1 0 decap_w0
xfeed_8744 1 0 decap_w0
xfeed_8743 1 0 decap_w0
xfeed_8742 1 0 decap_w0
xfeed_8741 1 0 decap_w0
xfeed_8740 1 0 decap_w0
xfeed_4439 1 0 decap_w0
xfeed_4438 1 0 decap_w0
xfeed_4437 1 0 decap_w0
xfeed_4436 1 0 decap_w0
xfeed_4435 1 0 decap_w0
xfeed_4434 1 0 decap_w0
xfeed_4433 1 0 decap_w0
xfeed_4432 1 0 decap_w0
xfeed_4431 1 0 decap_w0
xfeed_4430 1 0 decap_w0
xfeed_3908 1 0 decap_w0
xfeed_3907 1 0 decap_w0
xfeed_3906 1 0 decap_w0
xfeed_3905 1 0 decap_w0
xfeed_3904 1 0 decap_w0
xfeed_3903 1 0 decap_w0
xfeed_3902 1 0 decap_w0
xfeed_3901 1 0 decap_w0
xfeed_3900 1 0 decap_w0
xfeed_31799 1 0 decap_w0
xfeed_31798 1 0 decap_w0
xfeed_31797 1 0 decap_w0
xfeed_31796 1 0 decap_w0
xfeed_31795 1 0 decap_w0
xfeed_31794 1 0 decap_w0
xfeed_31793 1 0 decap_w0
xfeed_31792 1 0 decap_w0
xfeed_31791 1 0 decap_w0
xfeed_31790 1 0 decap_w0
xfeed_26409 1 0 decap_w0
xfeed_26408 1 0 decap_w0
xfeed_26407 1 0 decap_w0
xfeed_26406 1 0 decap_w0
xfeed_26405 1 0 decap_w0
xfeed_26404 1 0 decap_w0
xfeed_26403 1 0 decap_w0
xfeed_26402 1 0 decap_w0
xfeed_26401 1 0 decap_w0
xfeed_26400 1 0 decap_w0
xfeed_25799 1 0 decap_w0
xfeed_25798 1 0 decap_w0
xfeed_25797 1 0 decap_w0
xfeed_25796 1 0 decap_w0
xfeed_25795 1 0 decap_w0
xfeed_25794 1 0 decap_w0
xfeed_25793 1 0 decap_w0
xfeed_25792 1 0 decap_w0
xfeed_25791 1 0 decap_w0
xfeed_25790 1 0 decap_w0
xfeed_21489 1 0 decap_w0
xfeed_21488 1 0 decap_w0
xfeed_21487 1 0 decap_w0
xfeed_21486 1 0 decap_w0
xfeed_21485 1 0 decap_w0
xfeed_21484 1 0 decap_w0
xfeed_21483 1 0 decap_w0
xfeed_21482 1 0 decap_w0
xfeed_21481 1 0 decap_w0
xfeed_21480 1 0 decap_w0
xfeed_20959 1 0 decap_w0
xfeed_20958 1 0 decap_w0
xfeed_20957 1 0 decap_w0
xfeed_20956 1 0 decap_w0
xfeed_20955 1 0 decap_w0
xfeed_20954 1 0 decap_w0
xfeed_20953 1 0 decap_w0
xfeed_20952 1 0 decap_w0
xfeed_20951 1 0 decap_w0
xfeed_20950 1 0 decap_w0
xfeed_11176 1 0 decap_w0
xfeed_11175 1 0 decap_w0
xfeed_11174 1 0 decap_w0
xfeed_11173 1 0 decap_w0
xfeed_11172 1 0 decap_w0
xfeed_11171 1 0 decap_w0
xfeed_11170 1 0 decap_w0
xfeed_8749 1 0 decap_w0
xfeed_8748 1 0 decap_w0
xfeed_3909 1 0 decap_w0
xfeed_19799 1 0 decap_w0
xfeed_19798 1 0 decap_w0
xfeed_19797 1 0 decap_w0
xfeed_19796 1 0 decap_w0
xfeed_19795 1 0 decap_w0
xfeed_19794 1 0 decap_w0
xfeed_19793 1 0 decap_w0
xfeed_19792 1 0 decap_w0
xfeed_19791 1 0 decap_w0
xfeed_19790 1 0 decap_w0
xfeed_15489 1 0 decap_w0
xfeed_15488 1 0 decap_w0
xfeed_15487 1 0 decap_w0
xfeed_15486 1 0 decap_w0
xfeed_15485 1 0 decap_w0
xfeed_15484 1 0 decap_w0
xfeed_15483 1 0 decap_w0
xfeed_15482 1 0 decap_w0
xfeed_15481 1 0 decap_w0
xfeed_15480 1 0 decap_w0
xfeed_14959 1 0 decap_w0
xfeed_14958 1 0 decap_w0
xfeed_14957 1 0 decap_w0
xfeed_14956 1 0 decap_w0
xfeed_14955 1 0 decap_w0
xfeed_14954 1 0 decap_w0
xfeed_14953 1 0 decap_w0
xfeed_14952 1 0 decap_w0
xfeed_14951 1 0 decap_w0
xfeed_14950 1 0 decap_w0
xfeed_11179 1 0 decap_w0
xfeed_11178 1 0 decap_w0
xfeed_11177 1 0 decap_w0
xfeed_10649 1 0 decap_w0
xfeed_10648 1 0 decap_w0
xfeed_10647 1 0 decap_w0
xfeed_10646 1 0 decap_w0
xfeed_10645 1 0 decap_w0
xfeed_10644 1 0 decap_w0
xfeed_10643 1 0 decap_w0
xfeed_10642 1 0 decap_w0
xfeed_10641 1 0 decap_w0
xfeed_10640 1 0 decap_w0
xfeed_9289 1 0 decap_w0
xfeed_9288 1 0 decap_w0
xfeed_9287 1 0 decap_w0
xfeed_9286 1 0 decap_w0
xfeed_9285 1 0 decap_w0
xfeed_9284 1 0 decap_w0
xfeed_9283 1 0 decap_w0
xfeed_9282 1 0 decap_w0
xfeed_9281 1 0 decap_w0
xfeed_9280 1 0 decap_w0
xfeed_8754 1 0 decap_w0
xfeed_8753 1 0 decap_w0
xfeed_8752 1 0 decap_w0
xfeed_8751 1 0 decap_w0
xfeed_8750 1 0 decap_w0
xfeed_4449 1 0 decap_w0
xfeed_4448 1 0 decap_w0
xfeed_4447 1 0 decap_w0
xfeed_4446 1 0 decap_w0
xfeed_4445 1 0 decap_w0
xfeed_4444 1 0 decap_w0
xfeed_4443 1 0 decap_w0
xfeed_4442 1 0 decap_w0
xfeed_4441 1 0 decap_w0
xfeed_4440 1 0 decap_w0
xfeed_3915 1 0 decap_w0
xfeed_3914 1 0 decap_w0
xfeed_3913 1 0 decap_w0
xfeed_3912 1 0 decap_w0
xfeed_3911 1 0 decap_w0
xfeed_3910 1 0 decap_w0
xfeed_26419 1 0 decap_w0
xfeed_26418 1 0 decap_w0
xfeed_26417 1 0 decap_w0
xfeed_26416 1 0 decap_w0
xfeed_26415 1 0 decap_w0
xfeed_26414 1 0 decap_w0
xfeed_26413 1 0 decap_w0
xfeed_26412 1 0 decap_w0
xfeed_26411 1 0 decap_w0
xfeed_26410 1 0 decap_w0
xfeed_22109 1 0 decap_w0
xfeed_22108 1 0 decap_w0
xfeed_22107 1 0 decap_w0
xfeed_22106 1 0 decap_w0
xfeed_22105 1 0 decap_w0
xfeed_22104 1 0 decap_w0
xfeed_22103 1 0 decap_w0
xfeed_22102 1 0 decap_w0
xfeed_22101 1 0 decap_w0
xfeed_22100 1 0 decap_w0
xfeed_21499 1 0 decap_w0
xfeed_21498 1 0 decap_w0
xfeed_21497 1 0 decap_w0
xfeed_21496 1 0 decap_w0
xfeed_21495 1 0 decap_w0
xfeed_21494 1 0 decap_w0
xfeed_21493 1 0 decap_w0
xfeed_21492 1 0 decap_w0
xfeed_21491 1 0 decap_w0
xfeed_21490 1 0 decap_w0
xfeed_20969 1 0 decap_w0
xfeed_20968 1 0 decap_w0
xfeed_20967 1 0 decap_w0
xfeed_20966 1 0 decap_w0
xfeed_20965 1 0 decap_w0
xfeed_20964 1 0 decap_w0
xfeed_20963 1 0 decap_w0
xfeed_20962 1 0 decap_w0
xfeed_20961 1 0 decap_w0
xfeed_20960 1 0 decap_w0
xfeed_16109 1 0 decap_w0
xfeed_16108 1 0 decap_w0
xfeed_16107 1 0 decap_w0
xfeed_16106 1 0 decap_w0
xfeed_16105 1 0 decap_w0
xfeed_16104 1 0 decap_w0
xfeed_16103 1 0 decap_w0
xfeed_16102 1 0 decap_w0
xfeed_16101 1 0 decap_w0
xfeed_16100 1 0 decap_w0
xfeed_11183 1 0 decap_w0
xfeed_11182 1 0 decap_w0
xfeed_11181 1 0 decap_w0
xfeed_11180 1 0 decap_w0
xfeed_8759 1 0 decap_w0
xfeed_8758 1 0 decap_w0
xfeed_8757 1 0 decap_w0
xfeed_8756 1 0 decap_w0
xfeed_8755 1 0 decap_w0
xfeed_3919 1 0 decap_w0
xfeed_3918 1 0 decap_w0
xfeed_3917 1 0 decap_w0
xfeed_3916 1 0 decap_w0
xfeed_15499 1 0 decap_w0
xfeed_15498 1 0 decap_w0
xfeed_15497 1 0 decap_w0
xfeed_15496 1 0 decap_w0
xfeed_15495 1 0 decap_w0
xfeed_15494 1 0 decap_w0
xfeed_15493 1 0 decap_w0
xfeed_15492 1 0 decap_w0
xfeed_15491 1 0 decap_w0
xfeed_15490 1 0 decap_w0
xfeed_14969 1 0 decap_w0
xfeed_14968 1 0 decap_w0
xfeed_14967 1 0 tie
xfeed_14966 1 0 decap_w0
xfeed_14965 1 0 decap_w0
xfeed_14963 1 0 decap_w0
xfeed_14962 1 0 decap_w0
xfeed_14961 1 0 decap_w0
xfeed_14960 1 0 decap_w0
xfeed_11189 1 0 decap_w0
xfeed_11188 1 0 decap_w0
xfeed_11187 1 0 decap_w0
xfeed_11186 1 0 decap_w0
xfeed_11185 1 0 decap_w0
xfeed_11184 1 0 decap_w0
xfeed_10659 1 0 decap_w0
xfeed_10658 1 0 decap_w0
xfeed_10657 1 0 decap_w0
xfeed_10656 1 0 decap_w0
xfeed_10655 1 0 decap_w0
xfeed_10654 1 0 decap_w0
xfeed_10653 1 0 decap_w0
xfeed_10652 1 0 decap_w0
xfeed_10651 1 0 decap_w0
xfeed_10650 1 0 decap_w0
xfeed_9299 1 0 decap_w0
xfeed_9298 1 0 decap_w0
xfeed_9297 1 0 decap_w0
xfeed_9296 1 0 decap_w0
xfeed_9295 1 0 decap_w0
xfeed_9294 1 0 decap_w0
xfeed_9293 1 0 decap_w0
xfeed_9292 1 0 decap_w0
xfeed_9291 1 0 decap_w0
xfeed_9290 1 0 decap_w0
xfeed_8761 1 0 decap_w0
xfeed_8760 1 0 decap_w0
xfeed_4459 1 0 decap_w0
xfeed_4458 1 0 decap_w0
xfeed_4457 1 0 decap_w0
xfeed_4456 1 0 decap_w0
xfeed_4455 1 0 decap_w0
xfeed_4454 1 0 decap_w0
xfeed_4453 1 0 decap_w0
xfeed_4452 1 0 decap_w0
xfeed_4451 1 0 decap_w0
xfeed_4450 1 0 decap_w0
xfeed_3922 1 0 decap_w0
xfeed_3921 1 0 decap_w0
xfeed_3920 1 0 decap_w0
xfeed_26429 1 0 decap_w0
xfeed_26428 1 0 decap_w0
xfeed_26427 1 0 decap_w0
xfeed_26426 1 0 decap_w0
xfeed_26425 1 0 decap_w0
xfeed_26424 1 0 decap_w0
xfeed_26423 1 0 decap_w0
xfeed_26422 1 0 decap_w0
xfeed_26421 1 0 decap_w0
xfeed_26420 1 0 decap_w0
xfeed_22119 1 0 decap_w0
xfeed_22118 1 0 decap_w0
xfeed_22117 1 0 decap_w0
xfeed_22116 1 0 decap_w0
xfeed_22115 1 0 decap_w0
xfeed_22114 1 0 decap_w0
xfeed_22113 1 0 decap_w0
xfeed_22112 1 0 decap_w0
xfeed_22111 1 0 decap_w0
xfeed_22110 1 0 decap_w0
xfeed_20978 1 0 decap_w0
xfeed_20977 1 0 decap_w0
xfeed_20976 1 0 decap_w0
xfeed_20975 1 0 decap_w0
xfeed_20974 1 0 decap_w0
xfeed_20973 1 0 decap_w0
xfeed_20972 1 0 decap_w0
xfeed_20971 1 0 decap_w0
xfeed_20970 1 0 decap_w0
xfeed_16119 1 0 decap_w0
xfeed_16118 1 0 decap_w0
xfeed_16117 1 0 decap_w0
xfeed_16116 1 0 decap_w0
xfeed_16115 1 0 decap_w0
xfeed_16114 1 0 decap_w0
xfeed_16113 1 0 decap_w0
xfeed_16112 1 0 decap_w0
xfeed_16111 1 0 decap_w0
xfeed_16110 1 0 decap_w0
xfeed_11190 1 0 decap_w0
xfeed_8769 1 0 decap_w0
xfeed_8768 1 0 decap_w0
xfeed_8766 1 0 decap_w0
xfeed_8765 1 0 decap_w0
xfeed_8764 1 0 decap_w0
xfeed_8763 1 0 decap_w0
xfeed_8762 1 0 decap_w0
xfeed_3929 1 0 decap_w0
xfeed_3928 1 0 decap_w0
xfeed_3927 1 0 decap_w0
xfeed_3926 1 0 decap_w0
xfeed_3925 1 0 decap_w0
xfeed_3924 1 0 decap_w0
xfeed_3923 1 0 decap_w0
xfeed_20979 1 0 decap_w0
xfeed_14979 1 0 decap_w0
xfeed_14978 1 0 decap_w0
xfeed_14977 1 0 decap_w0
xfeed_14976 1 0 decap_w0
xfeed_14975 1 0 decap_w0
xfeed_14974 1 0 decap_w0
xfeed_14973 1 0 decap_w0
xfeed_14972 1 0 decap_w0
xfeed_14971 1 0 decap_w0
xfeed_14970 1 0 decap_w0
xfeed_11199 1 0 decap_w0
xfeed_11198 1 0 decap_w0
xfeed_11197 1 0 decap_w0
xfeed_11196 1 0 decap_w0
xfeed_11195 1 0 decap_w0
xfeed_11194 1 0 decap_w0
xfeed_11193 1 0 decap_w0
xfeed_11192 1 0 decap_w0
xfeed_11191 1 0 decap_w0
xfeed_10669 1 0 decap_w0
xfeed_10668 1 0 decap_w0
xfeed_10667 1 0 decap_w0
xfeed_10666 1 0 decap_w0
xfeed_10665 1 0 decap_w0
xfeed_10664 1 0 decap_w0
xfeed_10663 1 0 decap_w0
xfeed_10662 1 0 decap_w0
xfeed_10661 1 0 decap_w0
xfeed_10660 1 0 decap_w0
xfeed_4468 1 0 decap_w0
xfeed_4467 1 0 decap_w0
xfeed_4466 1 0 decap_w0
xfeed_4465 1 0 decap_w0
xfeed_4464 1 0 decap_w0
xfeed_4463 1 0 decap_w0
xfeed_4462 1 0 decap_w0
xfeed_4461 1 0 decap_w0
xfeed_4460 1 0 decap_w0
xfeed_31909 1 0 decap_w0
xfeed_31908 1 0 decap_w0
xfeed_31907 1 0 decap_w0
xfeed_31906 1 0 decap_w0
xfeed_31905 1 0 decap_w0
xfeed_31904 1 0 decap_w0
xfeed_31903 1 0 decap_w0
xfeed_31902 1 0 decap_w0
xfeed_31901 1 0 decap_w0
xfeed_31900 1 0 decap_w0
xfeed_26439 1 0 decap_w0
xfeed_26438 1 0 decap_w0
xfeed_26437 1 0 decap_w0
xfeed_26436 1 0 decap_w0
xfeed_26435 1 0 decap_w0
xfeed_26434 1 0 decap_w0
xfeed_26433 1 0 decap_w0
xfeed_26432 1 0 decap_w0
xfeed_26431 1 0 decap_w0
xfeed_26430 1 0 decap_w0
xfeed_25909 1 0 decap_w0
xfeed_25908 1 0 decap_w0
xfeed_25907 1 0 decap_w0
xfeed_25906 1 0 decap_w0
xfeed_25905 1 0 decap_w0
xfeed_25904 1 0 decap_w0
xfeed_25903 1 0 decap_w0
xfeed_25902 1 0 decap_w0
xfeed_25901 1 0 decap_w0
xfeed_25900 1 0 decap_w0
xfeed_22129 1 0 decap_w0
xfeed_22128 1 0 decap_w0
xfeed_22127 1 0 decap_w0
xfeed_22126 1 0 decap_w0
xfeed_22125 1 0 decap_w0
xfeed_22124 1 0 decap_w0
xfeed_22123 1 0 decap_w0
xfeed_22122 1 0 decap_w0
xfeed_22121 1 0 decap_w0
xfeed_22120 1 0 decap_w0
xfeed_20985 1 0 decap_w0
xfeed_20984 1 0 decap_w0
xfeed_20983 1 0 decap_w0
xfeed_20982 1 0 decap_w0
xfeed_20981 1 0 decap_w0
xfeed_20980 1 0 decap_w0
xfeed_16129 1 0 decap_w0
xfeed_16128 1 0 decap_w0
xfeed_16127 1 0 decap_w0
xfeed_16126 1 0 decap_w0
xfeed_16125 1 0 decap_w0
xfeed_16124 1 0 decap_w0
xfeed_16123 1 0 decap_w0
xfeed_16122 1 0 decap_w0
xfeed_16121 1 0 decap_w0
xfeed_16120 1 0 decap_w0
xfeed_8779 1 0 decap_w0
xfeed_8778 1 0 decap_w0
xfeed_8777 1 0 decap_w0
xfeed_8776 1 0 decap_w0
xfeed_8775 1 0 decap_w0
xfeed_8774 1 0 decap_w0
xfeed_8773 1 0 decap_w0
xfeed_8772 1 0 decap_w0
xfeed_8771 1 0 decap_w0
xfeed_8770 1 0 decap_w0
xfeed_4469 1 0 decap_w0
xfeed_3939 1 0 decap_w0
xfeed_3938 1 0 decap_w0
xfeed_3937 1 0 decap_w0
xfeed_3936 1 0 decap_w0
xfeed_3935 1 0 decap_w0
xfeed_3934 1 0 decap_w0
xfeed_3933 1 0 decap_w0
xfeed_3932 1 0 decap_w0
xfeed_3931 1 0 decap_w0
xfeed_3930 1 0 decap_w0
xfeed_20989 1 0 decap_w0
xfeed_20988 1 0 decap_w0
xfeed_20987 1 0 decap_w0
xfeed_20986 1 0 decap_w0
xfeed_19909 1 0 decap_w0
xfeed_19908 1 0 decap_w0
xfeed_19907 1 0 decap_w0
xfeed_19906 1 0 decap_w0
xfeed_19905 1 0 decap_w0
xfeed_19904 1 0 decap_w0
xfeed_19903 1 0 decap_w0
xfeed_19902 1 0 decap_w0
xfeed_19901 1 0 decap_w0
xfeed_19900 1 0 decap_w0
xfeed_14989 1 0 decap_w0
xfeed_14988 1 0 decap_w0
xfeed_14987 1 0 decap_w0
xfeed_14986 1 0 decap_w0
xfeed_14985 1 0 decap_w0
xfeed_14984 1 0 decap_w0
xfeed_14983 1 0 decap_w0
xfeed_14982 1 0 decap_w0
xfeed_14981 1 0 decap_w0
xfeed_14980 1 0 decap_w0
xfeed_10679 1 0 decap_w0
xfeed_10678 1 0 tie
xfeed_10677 1 0 decap_w0
xfeed_10676 1 0 decap_w0
xfeed_10675 1 0 decap_w0
xfeed_10674 1 0 decap_w0
xfeed_10673 1 0 decap_w0
xfeed_10672 1 0 decap_w0
xfeed_10671 1 0 decap_w0
xfeed_10670 1 0 decap_w0
xfeed_4475 1 0 decap_w0
xfeed_4474 1 0 decap_w0
xfeed_4473 1 0 decap_w0
xfeed_4472 1 0 decap_w0
xfeed_4471 1 0 decap_w0
xfeed_4470 1 0 decap_w0
xfeed_31919 1 0 decap_w0
xfeed_31918 1 0 decap_w0
xfeed_31917 1 0 decap_w0
xfeed_31916 1 0 decap_w0
xfeed_31915 1 0 decap_w0
xfeed_31914 1 0 decap_w0
xfeed_31913 1 0 decap_w0
xfeed_31912 1 0 decap_w0
xfeed_31911 1 0 decap_w0
xfeed_31910 1 0 decap_w0
xfeed_26449 1 0 decap_w0
xfeed_26448 1 0 decap_w0
xfeed_26447 1 0 decap_w0
xfeed_26446 1 0 decap_w0
xfeed_26445 1 0 decap_w0
xfeed_26444 1 0 decap_w0
xfeed_26443 1 0 decap_w0
xfeed_26442 1 0 decap_w0
xfeed_26441 1 0 decap_w0
xfeed_26440 1 0 decap_w0
xfeed_25919 1 0 decap_w0
xfeed_25918 1 0 decap_w0
xfeed_25917 1 0 decap_w0
xfeed_25916 1 0 decap_w0
xfeed_25915 1 0 decap_w0
xfeed_25914 1 0 decap_w0
xfeed_25913 1 0 decap_w0
xfeed_25912 1 0 decap_w0
xfeed_25911 1 0 decap_w0
xfeed_25910 1 0 decap_w0
xfeed_22139 1 0 decap_w0
xfeed_22138 1 0 decap_w0
xfeed_22137 1 0 decap_w0
xfeed_22136 1 0 decap_w0
xfeed_22135 1 0 decap_w0
xfeed_22134 1 0 decap_w0
xfeed_22133 1 0 decap_w0
xfeed_22132 1 0 decap_w0
xfeed_22131 1 0 decap_w0
xfeed_22130 1 0 decap_w0
xfeed_21609 1 0 decap_w0
xfeed_21608 1 0 decap_w0
xfeed_21607 1 0 decap_w0
xfeed_21606 1 0 decap_w0
xfeed_21605 1 0 decap_w0
xfeed_21604 1 0 decap_w0
xfeed_21603 1 0 decap_w0
xfeed_21602 1 0 decap_w0
xfeed_21601 1 0 decap_w0
xfeed_21600 1 0 decap_w0
xfeed_20992 1 0 decap_w0
xfeed_20991 1 0 decap_w0
xfeed_20990 1 0 decap_w0
xfeed_16139 1 0 decap_w0
xfeed_16138 1 0 decap_w0
xfeed_16137 1 0 decap_w0
xfeed_16136 1 0 decap_w0
xfeed_16135 1 0 decap_w0
xfeed_16134 1 0 decap_w0
xfeed_16133 1 0 decap_w0
xfeed_16132 1 0 decap_w0
xfeed_16131 1 0 decap_w0
xfeed_16130 1 0 decap_w0
xfeed_15602 1 0 decap_w0
xfeed_15601 1 0 decap_w0
xfeed_15600 1 0 decap_w0
xfeed_8789 1 0 decap_w0
xfeed_8788 1 0 decap_w0
xfeed_8787 1 0 decap_w0
xfeed_8786 1 0 decap_w0
xfeed_8785 1 0 decap_w0
xfeed_8784 1 0 decap_w0
xfeed_8783 1 0 decap_w0
xfeed_8782 1 0 decap_w0
xfeed_8781 1 0 decap_w0
xfeed_8780 1 0 decap_w0
xfeed_4479 1 0 decap_w0
xfeed_4478 1 0 decap_w0
xfeed_4477 1 0 decap_w0
xfeed_4476 1 0 decap_w0
xfeed_3949 1 0 decap_w0
xfeed_3948 1 0 decap_w0
xfeed_3947 1 0 decap_w0
xfeed_3946 1 0 decap_w0
xfeed_3945 1 0 decap_w0
xfeed_3944 1 0 decap_w0
xfeed_3943 1 0 decap_w0
xfeed_3942 1 0 decap_w0
xfeed_3941 1 0 decap_w0
xfeed_3940 1 0 decap_w0
xfeed_20999 1 0 decap_w0
xfeed_20998 1 0 decap_w0
xfeed_20997 1 0 decap_w0
xfeed_20996 1 0 decap_w0
xfeed_20995 1 0 decap_w0
xfeed_20994 1 0 decap_w0
xfeed_20993 1 0 decap_w0
xfeed_19919 1 0 decap_w0
xfeed_19918 1 0 decap_w0
xfeed_19917 1 0 decap_w0
xfeed_19916 1 0 decap_w0
xfeed_19915 1 0 decap_w0
xfeed_19914 1 0 decap_w0
xfeed_19913 1 0 decap_w0
xfeed_19912 1 0 decap_w0
xfeed_19911 1 0 decap_w0
xfeed_19910 1 0 decap_w0
xfeed_15609 1 0 decap_w0
xfeed_15608 1 0 decap_w0
xfeed_15607 1 0 decap_w0
xfeed_15606 1 0 decap_w0
xfeed_15605 1 0 decap_w0
xfeed_15604 1 0 decap_w0
xfeed_15603 1 0 tie
xfeed_14999 1 0 decap_w0
xfeed_14998 1 0 decap_w0
xfeed_14997 1 0 decap_w0
xfeed_14996 1 0 decap_w0
xfeed_14995 1 0 decap_w0
xfeed_14994 1 0 decap_w0
xfeed_14993 1 0 decap_w0
xfeed_14992 1 0 decap_w0
xfeed_14991 1 0 decap_w0
xfeed_14990 1 0 decap_w0
xfeed_10689 1 0 decap_w0
xfeed_10688 1 0 decap_w0
xfeed_10687 1 0 decap_w0
xfeed_10686 1 0 decap_w0
xfeed_10685 1 0 decap_w0
xfeed_10684 1 0 decap_w0
xfeed_10683 1 0 decap_w0
xfeed_10682 1 0 decap_w0
xfeed_10681 1 0 decap_w0
xfeed_10680 1 0 decap_w0
xfeed_9409 1 0 decap_w0
xfeed_9408 1 0 decap_w0
xfeed_9407 1 0 decap_w0
xfeed_9406 1 0 decap_w0
xfeed_9405 1 0 decap_w0
xfeed_9404 1 0 decap_w0
xfeed_9403 1 0 decap_w0
xfeed_9402 1 0 decap_w0
xfeed_9401 1 0 decap_w0
xfeed_9400 1 0 decap_w0
xfeed_4482 1 0 decap_w0
xfeed_4481 1 0 decap_w0
xfeed_4480 1 0 decap_w0
xfeed_31929 1 0 decap_w0
xfeed_31928 1 0 decap_w0
xfeed_31927 1 0 decap_w0
xfeed_31926 1 0 decap_w0
xfeed_31925 1 0 decap_w0
xfeed_31924 1 0 decap_w0
xfeed_31923 1 0 decap_w0
xfeed_31922 1 0 decap_w0
xfeed_31921 1 0 decap_w0
xfeed_31920 1 0 decap_w0
xfeed_26459 1 0 decap_w0
xfeed_26458 1 0 decap_w0
xfeed_26457 1 0 decap_w0
xfeed_26456 1 0 decap_w0
xfeed_26455 1 0 decap_w0
xfeed_26454 1 0 decap_w0
xfeed_26453 1 0 decap_w0
xfeed_26452 1 0 decap_w0
xfeed_26451 1 0 decap_w0
xfeed_26450 1 0 decap_w0
xfeed_25929 1 0 decap_w0
xfeed_25928 1 0 decap_w0
xfeed_25927 1 0 decap_w0
xfeed_25926 1 0 decap_w0
xfeed_25925 1 0 decap_w0
xfeed_25924 1 0 decap_w0
xfeed_25923 1 0 decap_w0
xfeed_25922 1 0 decap_w0
xfeed_25921 1 0 decap_w0
xfeed_25920 1 0 decap_w0
xfeed_22149 1 0 decap_w0
xfeed_22148 1 0 decap_w0
xfeed_22147 1 0 decap_w0
xfeed_22146 1 0 decap_w0
xfeed_22145 1 0 decap_w0
xfeed_22144 1 0 decap_w0
xfeed_22143 1 0 decap_w0
xfeed_22142 1 0 decap_w0
xfeed_22141 1 0 decap_w0
xfeed_22140 1 0 decap_w0
xfeed_21619 1 0 decap_w0
xfeed_21618 1 0 decap_w0
xfeed_21617 1 0 decap_w0
xfeed_21616 1 0 decap_w0
xfeed_21615 1 0 decap_w0
xfeed_21614 1 0 decap_w0
xfeed_21613 1 0 decap_w0
xfeed_21612 1 0 decap_w0
xfeed_21611 1 0 decap_w0
xfeed_21610 1 0 decap_w0
xfeed_16148 1 0 decap_w0
xfeed_16147 1 0 decap_w0
xfeed_16146 1 0 decap_w0
xfeed_16145 1 0 decap_w0
xfeed_16144 1 0 decap_w0
xfeed_16143 1 0 decap_w0
xfeed_16142 1 0 decap_w0
xfeed_16141 1 0 decap_w0
xfeed_16140 1 0 decap_w0
xfeed_11309 1 0 decap_w0
xfeed_11308 1 0 decap_w0
xfeed_11307 1 0 decap_w0
xfeed_11306 1 0 decap_w0
xfeed_11305 1 0 decap_w0
xfeed_11304 1 0 decap_w0
xfeed_11303 1 0 decap_w0
xfeed_11302 1 0 decap_w0
xfeed_11301 1 0 decap_w0
xfeed_11300 1 0 decap_w0
xfeed_8799 1 0 decap_w0
xfeed_8798 1 0 decap_w0
xfeed_8797 1 0 decap_w0
xfeed_8796 1 0 decap_w0
xfeed_8795 1 0 decap_w0
xfeed_8794 1 0 decap_w0
xfeed_8793 1 0 decap_w0
xfeed_8792 1 0 decap_w0
xfeed_8791 1 0 decap_w0
xfeed_8790 1 0 decap_w0
xfeed_4489 1 0 decap_w0
xfeed_4488 1 0 decap_w0
xfeed_4487 1 0 decap_w0
xfeed_4486 1 0 decap_w0
xfeed_4485 1 0 decap_w0
xfeed_4484 1 0 decap_w0
xfeed_4483 1 0 decap_w0
xfeed_3959 1 0 decap_w0
xfeed_3958 1 0 decap_w0
xfeed_3957 1 0 decap_w0
xfeed_3956 1 0 decap_w0
xfeed_3955 1 0 decap_w0
xfeed_3954 1 0 decap_w0
xfeed_3953 1 0 decap_w0
xfeed_3952 1 0 decap_w0
xfeed_3951 1 0 decap_w0
xfeed_3950 1 0 decap_w0
xfeed_19929 1 0 decap_w0
xfeed_19928 1 0 decap_w0
xfeed_19927 1 0 decap_w0
xfeed_19926 1 0 decap_w0
xfeed_19925 1 0 decap_w0
xfeed_19924 1 0 decap_w0
xfeed_19923 1 0 decap_w0
xfeed_19922 1 0 decap_w0
xfeed_19921 1 0 decap_w0
xfeed_19920 1 0 decap_w0
xfeed_16149 1 0 decap_w0
xfeed_15619 1 0 decap_w0
xfeed_15618 1 0 decap_w0
xfeed_15617 1 0 decap_w0
xfeed_15616 1 0 decap_w0
xfeed_15615 1 0 decap_w0
xfeed_15614 1 0 decap_w0
xfeed_15613 1 0 decap_w0
xfeed_15612 1 0 decap_w0
xfeed_15611 1 0 decap_w0
xfeed_15610 1 0 decap_w0
xfeed_10699 1 0 decap_w0
xfeed_10698 1 0 decap_w0
xfeed_10697 1 0 decap_w0
xfeed_10696 1 0 decap_w0
xfeed_10695 1 0 decap_w0
xfeed_10694 1 0 decap_w0
xfeed_10693 1 0 decap_w0
xfeed_10692 1 0 decap_w0
xfeed_10691 1 0 decap_w0
xfeed_10690 1 0 decap_w0
xfeed_9419 1 0 decap_w0
xfeed_9418 1 0 decap_w0
xfeed_9417 1 0 decap_w0
xfeed_9416 1 0 decap_w0
xfeed_9415 1 0 decap_w0
xfeed_9414 1 0 decap_w0
xfeed_9413 1 0 decap_w0
xfeed_9412 1 0 decap_w0
xfeed_9411 1 0 decap_w0
xfeed_9410 1 0 decap_w0
xfeed_5109 1 0 decap_w0
xfeed_5108 1 0 decap_w0
xfeed_5107 1 0 decap_w0
xfeed_5106 1 0 decap_w0
xfeed_5105 1 0 decap_w0
xfeed_5104 1 0 decap_w0
xfeed_5103 1 0 decap_w0
xfeed_5102 1 0 decap_w0
xfeed_5101 1 0 decap_w0
xfeed_5100 1 0 decap_w0
xfeed_31939 1 0 decap_w0
xfeed_31938 1 0 decap_w0
xfeed_31937 1 0 decap_w0
xfeed_31936 1 0 decap_w0
xfeed_31935 1 0 decap_w0
xfeed_31934 1 0 decap_w0
xfeed_31933 1 0 decap_w0
xfeed_31932 1 0 decap_w0
xfeed_31931 1 0 decap_w0
xfeed_31930 1 0 decap_w0
xfeed_26469 1 0 decap_w0
xfeed_26468 1 0 decap_w0
xfeed_26467 1 0 decap_w0
xfeed_26466 1 0 decap_w0
xfeed_26465 1 0 decap_w0
xfeed_26464 1 0 decap_w0
xfeed_26463 1 0 decap_w0
xfeed_26462 1 0 decap_w0
xfeed_26461 1 0 decap_w0
xfeed_26460 1 0 decap_w0
xfeed_25939 1 0 decap_w0
xfeed_25938 1 0 decap_w0
xfeed_25937 1 0 decap_w0
xfeed_25936 1 0 decap_w0
xfeed_25935 1 0 decap_w0
xfeed_25934 1 0 decap_w0
xfeed_25933 1 0 decap_w0
xfeed_25932 1 0 decap_w0
xfeed_25931 1 0 decap_w0
xfeed_25930 1 0 decap_w0
xfeed_22159 1 0 decap_w0
xfeed_22158 1 0 decap_w0
xfeed_22157 1 0 decap_w0
xfeed_22156 1 0 decap_w0
xfeed_22155 1 0 decap_w0
xfeed_22154 1 0 decap_w0
xfeed_22153 1 0 decap_w0
xfeed_22152 1 0 decap_w0
xfeed_22151 1 0 decap_w0
xfeed_22150 1 0 decap_w0
xfeed_21629 1 0 decap_w0
xfeed_21628 1 0 decap_w0
xfeed_21627 1 0 decap_w0
xfeed_21626 1 0 decap_w0
xfeed_21625 1 0 decap_w0
xfeed_21624 1 0 decap_w0
xfeed_21623 1 0 decap_w0
xfeed_21622 1 0 decap_w0
xfeed_21621 1 0 decap_w0
xfeed_21620 1 0 decap_w0
xfeed_16155 1 0 decap_w0
xfeed_16154 1 0 decap_w0
xfeed_16153 1 0 decap_w0
xfeed_16152 1 0 decap_w0
xfeed_16151 1 0 decap_w0
xfeed_16150 1 0 decap_w0
xfeed_11316 1 0 decap_w0
xfeed_11315 1 0 decap_w0
xfeed_11314 1 0 decap_w0
xfeed_11313 1 0 decap_w0
xfeed_11312 1 0 decap_w0
xfeed_11311 1 0 decap_w0
xfeed_11310 1 0 decap_w0
xfeed_4499 1 0 decap_w0
xfeed_4498 1 0 decap_w0
xfeed_4497 1 0 decap_w0
xfeed_4496 1 0 decap_w0
xfeed_4495 1 0 decap_w0
xfeed_4494 1 0 decap_w0
xfeed_4493 1 0 decap_w0
xfeed_4492 1 0 decap_w0
xfeed_4491 1 0 decap_w0
xfeed_4490 1 0 decap_w0
xfeed_3969 1 0 decap_w0
xfeed_3968 1 0 decap_w0
xfeed_3967 1 0 decap_w0
xfeed_3966 1 0 decap_w0
xfeed_3965 1 0 decap_w0
xfeed_3964 1 0 decap_w0
xfeed_3963 1 0 decap_w0
xfeed_3962 1 0 decap_w0
xfeed_3961 1 0 decap_w0
xfeed_3960 1 0 decap_w0
xfeed_19939 1 0 decap_w0
xfeed_19938 1 0 decap_w0
xfeed_19937 1 0 decap_w0
xfeed_19936 1 0 decap_w0
xfeed_19935 1 0 decap_w0
xfeed_19934 1 0 decap_w0
xfeed_19933 1 0 decap_w0
xfeed_19932 1 0 decap_w0
xfeed_19931 1 0 decap_w0
xfeed_19930 1 0 decap_w0
xfeed_16159 1 0 decap_w0
xfeed_16158 1 0 decap_w0
xfeed_16157 1 0 decap_w0
xfeed_16156 1 0 decap_w0
xfeed_15629 1 0 decap_w0
xfeed_15628 1 0 decap_w0
xfeed_15627 1 0 decap_w0
xfeed_15626 1 0 decap_w0
xfeed_15625 1 0 decap_w0
xfeed_15624 1 0 decap_w0
xfeed_15623 1 0 decap_w0
xfeed_15622 1 0 decap_w0
xfeed_15621 1 0 decap_w0
xfeed_15620 1 0 decap_w0
xfeed_11319 1 0 decap_w0
xfeed_11318 1 0 decap_w0
xfeed_11317 1 0 decap_w0
xfeed_9429 1 0 decap_w0
xfeed_9428 1 0 decap_w0
xfeed_9427 1 0 decap_w0
xfeed_9426 1 0 decap_w0
xfeed_9425 1 0 decap_w0
xfeed_9424 1 0 decap_w0
xfeed_9423 1 0 decap_w0
xfeed_9422 1 0 decap_w0
xfeed_9421 1 0 decap_w0
xfeed_9420 1 0 decap_w0
xfeed_5119 1 0 decap_w0
xfeed_5118 1 0 decap_w0
xfeed_5117 1 0 decap_w0
xfeed_5116 1 0 decap_w0
xfeed_5115 1 0 decap_w0
xfeed_5114 1 0 decap_w0
xfeed_5113 1 0 decap_w0
xfeed_5112 1 0 decap_w0
xfeed_5111 1 0 decap_w0
xfeed_5110 1 0 decap_w0
xsubckt_50_nexor2_x0 1 0 176 7 6 nexor2_x0
xsubckt_2_nexor2_x0 1 0 56 64 137 nexor2_x0
xfeed_31949 1 0 decap_w0
xfeed_31948 1 0 decap_w0
xfeed_31947 1 0 decap_w0
xfeed_31946 1 0 decap_w0
xfeed_31945 1 0 decap_w0
xfeed_31944 1 0 decap_w0
xfeed_31943 1 0 decap_w0
xfeed_31942 1 0 decap_w0
xfeed_31941 1 0 decap_w0
xfeed_31940 1 0 decap_w0
xfeed_26479 1 0 decap_w0
xfeed_26478 1 0 decap_w0
xfeed_26477 1 0 decap_w0
xfeed_26476 1 0 decap_w0
xfeed_26475 1 0 decap_w0
xfeed_26474 1 0 decap_w0
xfeed_26473 1 0 decap_w0
xfeed_26472 1 0 decap_w0
xfeed_26471 1 0 decap_w0
xfeed_26470 1 0 decap_w0
xfeed_25949 1 0 decap_w0
xfeed_25948 1 0 decap_w0
xfeed_25947 1 0 decap_w0
xfeed_25946 1 0 decap_w0
xfeed_25945 1 0 decap_w0
xfeed_25944 1 0 decap_w0
xfeed_25943 1 0 decap_w0
xfeed_25942 1 0 decap_w0
xfeed_25941 1 0 decap_w0
xfeed_25940 1 0 decap_w0
xfeed_22169 1 0 decap_w0
xfeed_22168 1 0 decap_w0
xfeed_22167 1 0 decap_w0
xfeed_22166 1 0 decap_w0
xfeed_22165 1 0 decap_w0
xfeed_22164 1 0 decap_w0
xfeed_22163 1 0 decap_w0
xfeed_22162 1 0 decap_w0
xfeed_22161 1 0 decap_w0
xfeed_22160 1 0 decap_w0
xfeed_21639 1 0 decap_w0
xfeed_21638 1 0 decap_w0
xfeed_21637 1 0 decap_w0
xfeed_21636 1 0 decap_w0
xfeed_21635 1 0 decap_w0
xfeed_21634 1 0 decap_w0
xfeed_21633 1 0 decap_w0
xfeed_21632 1 0 decap_w0
xfeed_21631 1 0 decap_w0
xfeed_21630 1 0 decap_w0
xfeed_16162 1 0 decap_w0
xfeed_16161 1 0 decap_w0
xfeed_16160 1 0 decap_w0
xfeed_11323 1 0 decap_w0
xfeed_11322 1 0 decap_w0
xfeed_11321 1 0 decap_w0
xfeed_11320 1 0 decap_w0
xfeed_3979 1 0 decap_w0
xfeed_3978 1 0 decap_w0
xfeed_3977 1 0 decap_w0
xfeed_3976 1 0 decap_w0
xfeed_3975 1 0 decap_w0
xfeed_3974 1 0 decap_w0
xfeed_3973 1 0 decap_w0
xfeed_3972 1 0 decap_w0
xfeed_3971 1 0 decap_w0
xfeed_3970 1 0 decap_w0
xsubckt_32_nexor2_x0 1 0 118 137 117 nexor2_x0
xfeed_19949 1 0 decap_w0
xfeed_19948 1 0 decap_w0
xfeed_19947 1 0 decap_w0
xfeed_19946 1 0 decap_w0
xfeed_19945 1 0 decap_w0
xfeed_19944 1 0 decap_w0
xfeed_19943 1 0 decap_w0
xfeed_19942 1 0 decap_w0
xfeed_19941 1 0 decap_w0
xfeed_19940 1 0 decap_w0
xfeed_16169 1 0 decap_w0
xfeed_16168 1 0 decap_w0
xfeed_16167 1 0 decap_w0
xfeed_16166 1 0 decap_w0
xfeed_16165 1 0 decap_w0
xfeed_16164 1 0 decap_w0
xfeed_16163 1 0 decap_w0
xfeed_15639 1 0 decap_w0
xfeed_15638 1 0 decap_w0
xfeed_15637 1 0 decap_w0
xfeed_15636 1 0 decap_w0
xfeed_15635 1 0 decap_w0
xfeed_15634 1 0 decap_w0
xfeed_15633 1 0 decap_w0
xfeed_15632 1 0 decap_w0
xfeed_15631 1 0 decap_w0
xfeed_15630 1 0 decap_w0
xfeed_11329 1 0 decap_w0
xfeed_11328 1 0 decap_w0
xfeed_11327 1 0 decap_w0
xfeed_11326 1 0 decap_w0
xfeed_11325 1 0 decap_w0
xfeed_11324 1 0 decap_w0
xfeed_9439 1 0 decap_w0
xfeed_9438 1 0 decap_w0
xfeed_9437 1 0 decap_w0
xfeed_9436 1 0 decap_w0
xfeed_9435 1 0 decap_w0
xfeed_9434 1 0 decap_w0
xfeed_9433 1 0 decap_w0
xfeed_9432 1 0 decap_w0
xfeed_9431 1 0 decap_w0
xfeed_9430 1 0 decap_w0
xfeed_8901 1 0 decap_w0
xfeed_8900 1 0 decap_w0
xfeed_5129 1 0 decap_w0
xfeed_5128 1 0 decap_w0
xfeed_5127 1 0 decap_w0
xfeed_5126 1 0 decap_w0
xfeed_5125 1 0 decap_w0
xfeed_5124 1 0 decap_w0
xfeed_5123 1 0 decap_w0
xfeed_5122 1 0 decap_w0
xfeed_5121 1 0 decap_w0
xfeed_5120 1 0 decap_w0
xfeed_31959 1 0 decap_w0
xfeed_31958 1 0 decap_w0
xfeed_31957 1 0 decap_w0
xfeed_31956 1 0 decap_w0
xfeed_31955 1 0 decap_w0
xfeed_31954 1 0 decap_w0
xfeed_31953 1 0 decap_w0
xfeed_31952 1 0 decap_w0
xfeed_31951 1 0 decap_w0
xfeed_31950 1 0 decap_w0
xfeed_26489 1 0 decap_w0
xfeed_26488 1 0 decap_w0
xfeed_26487 1 0 decap_w0
xfeed_26486 1 0 decap_w0
xfeed_26485 1 0 decap_w0
xfeed_26484 1 0 decap_w0
xfeed_26483 1 0 decap_w0
xfeed_26482 1 0 decap_w0
xfeed_26481 1 0 decap_w0
xfeed_26480 1 0 decap_w0
xfeed_25957 1 0 decap_w0
xfeed_25956 1 0 decap_w0
xfeed_25955 1 0 decap_w0
xfeed_25954 1 0 decap_w0
xfeed_25953 1 0 decap_w0
xfeed_25952 1 0 decap_w0
xfeed_25951 1 0 decap_w0
xfeed_25950 1 0 decap_w0
xfeed_22179 1 0 decap_w0
xfeed_22178 1 0 decap_w0
xfeed_22177 1 0 decap_w0
xfeed_22176 1 0 decap_w0
xfeed_22175 1 0 decap_w0
xfeed_22174 1 0 decap_w0
xfeed_22173 1 0 decap_w0
xfeed_22172 1 0 decap_w0
xfeed_22171 1 0 decap_w0
xfeed_22170 1 0 decap_w0
xfeed_21649 1 0 decap_w0
xfeed_21648 1 0 decap_w0
xfeed_21647 1 0 decap_w0
xfeed_21646 1 0 decap_w0
xfeed_21645 1 0 decap_w0
xfeed_21644 1 0 decap_w0
xfeed_21643 1 0 decap_w0
xfeed_21642 1 0 decap_w0
xfeed_21641 1 0 decap_w0
xfeed_21640 1 0 decap_w0
xfeed_11330 1 0 decap_w0
xfeed_8909 1 0 decap_w0
xfeed_8908 1 0 decap_w0
xfeed_8907 1 0 decap_w0
xfeed_8906 1 0 decap_w0
xfeed_8905 1 0 decap_w0
xfeed_8904 1 0 decap_w0
xfeed_8903 1 0 decap_w0
xfeed_8902 1 0 decap_w0
xfeed_3989 1 0 decap_w0
xfeed_3988 1 0 decap_w0
xfeed_3987 1 0 decap_w0
xfeed_3986 1 0 decap_w0
xfeed_3985 1 0 decap_w0
xfeed_3984 1 0 decap_w0
xfeed_3983 1 0 decap_w0
xfeed_3982 1 0 decap_w0
xfeed_3981 1 0 decap_w0
xfeed_3980 1 0 decap_w0
xsubckt_14_nexor2_x0 1 0 43 60 130 nexor2_x0
xfeed_25959 1 0 decap_w0
xfeed_25958 1 0 decap_w0
xfeed_19959 1 0 decap_w0
xfeed_19958 1 0 decap_w0
xfeed_19957 1 0 decap_w0
xfeed_19956 1 0 decap_w0
xfeed_19955 1 0 decap_w0
xfeed_19954 1 0 decap_w0
xfeed_19953 1 0 decap_w0
xfeed_19952 1 0 decap_w0
xfeed_19951 1 0 decap_w0
xfeed_19950 1 0 decap_w0
xfeed_16179 1 0 decap_w0
xfeed_16178 1 0 decap_w0
xfeed_16177 1 0 decap_w0
xfeed_16176 1 0 decap_w0
xfeed_16175 1 0 decap_w0
xfeed_16174 1 0 decap_w0
xfeed_16173 1 0 decap_w0
xfeed_16172 1 0 decap_w0
xfeed_16171 1 0 decap_w0
xfeed_16170 1 0 decap_w0
xfeed_15649 1 0 decap_w0
xfeed_15648 1 0 decap_w0
xfeed_15647 1 0 decap_w0
xfeed_15646 1 0 decap_w0
xfeed_15645 1 0 decap_w0
xfeed_15644 1 0 decap_w0
xfeed_15643 1 0 decap_w0
xfeed_15642 1 0 decap_w0
xfeed_15641 1 0 decap_w0
xfeed_15640 1 0 decap_w0
xfeed_11339 1 0 decap_w0
xfeed_11338 1 0 decap_w0
xfeed_11337 1 0 decap_w0
xfeed_11336 1 0 decap_w0
xfeed_11335 1 0 decap_w0
xfeed_11334 1 0 decap_w0
xfeed_11333 1 0 decap_w0
xfeed_11332 1 0 decap_w0
xfeed_11331 1 0 decap_w0
xfeed_10809 1 0 decap_w0
xfeed_10808 1 0 decap_w0
xfeed_10807 1 0 decap_w0
xfeed_10806 1 0 decap_w0
xfeed_10805 1 0 decap_w0
xfeed_10804 1 0 decap_w0
xfeed_10803 1 0 decap_w0
xfeed_10802 1 0 decap_w0
xfeed_10801 1 0 decap_w0
xfeed_10800 1 0 decap_w0
xfeed_9447 1 0 decap_w0
xfeed_9446 1 0 decap_w0
xfeed_9445 1 0 decap_w0
xfeed_9444 1 0 decap_w0
xfeed_9443 1 0 decap_w0
xfeed_9442 1 0 decap_w0
xfeed_9441 1 0 decap_w0
xfeed_9440 1 0 decap_w0
xfeed_5139 1 0 decap_w0
xfeed_5138 1 0 decap_w0
xfeed_5137 1 0 decap_w0
xfeed_5136 1 0 decap_w0
xfeed_5135 1 0 decap_w0
xfeed_5134 1 0 decap_w0
xfeed_5133 1 0 decap_w0
xfeed_5132 1 0 decap_w0
xfeed_5131 1 0 decap_w0
xfeed_5130 1 0 decap_w0
xfeed_4608 1 0 decap_w0
xfeed_4607 1 0 decap_w0
xfeed_4606 1 0 decap_w0
xfeed_4605 1 0 decap_w0
xfeed_4604 1 0 decap_w0
xfeed_4603 1 0 decap_w0
xfeed_4602 1 0 decap_w0
xfeed_4601 1 0 decap_w0
xfeed_4600 1 0 decap_w0
xfeed_31969 1 0 decap_w0
xfeed_31968 1 0 decap_w0
xfeed_31967 1 0 decap_w0
xfeed_31966 1 0 decap_w0
xfeed_31965 1 0 decap_w0
xfeed_31964 1 0 decap_w0
xfeed_31963 1 0 decap_w0
xfeed_31962 1 0 decap_w0
xfeed_31961 1 0 decap_w0
xfeed_31960 1 0 decap_w0
xfeed_27109 1 0 decap_w0
xfeed_27108 1 0 decap_w0
xfeed_27107 1 0 decap_w0
xfeed_27106 1 0 decap_w0
xfeed_27105 1 0 decap_w0
xfeed_27104 1 0 decap_w0
xfeed_27103 1 0 decap_w0
xfeed_27102 1 0 decap_w0
xfeed_27101 1 0 decap_w0
xfeed_27100 1 0 decap_w0
xfeed_26499 1 0 decap_w0
xfeed_26498 1 0 decap_w0
xfeed_26497 1 0 decap_w0
xfeed_26496 1 0 decap_w0
xfeed_26495 1 0 decap_w0
xfeed_26494 1 0 decap_w0
xfeed_26493 1 0 decap_w0
xfeed_26492 1 0 decap_w0
xfeed_26491 1 0 decap_w0
xfeed_26490 1 0 decap_w0
xfeed_25964 1 0 decap_w0
xfeed_25963 1 0 decap_w0
xfeed_25962 1 0 decap_w0
xfeed_25961 1 0 decap_w0
xfeed_25960 1 0 decap_w0
xfeed_22189 1 0 decap_w0
xfeed_22188 1 0 decap_w0
xfeed_22187 1 0 decap_w0
xfeed_22186 1 0 decap_w0
xfeed_22185 1 0 decap_w0
xfeed_22184 1 0 decap_w0
xfeed_22183 1 0 decap_w0
xfeed_22182 1 0 decap_w0
xfeed_22181 1 0 decap_w0
xfeed_22180 1 0 decap_w0
xfeed_21659 1 0 decap_w0
xfeed_21658 1 0 decap_w0
xfeed_21657 1 0 decap_w0
xfeed_21656 1 0 decap_w0
xfeed_21655 1 0 decap_w0
xfeed_21654 1 0 decap_w0
xfeed_21653 1 0 decap_w0
xfeed_21652 1 0 decap_w0
xfeed_21651 1 0 decap_w0
xfeed_21650 1 0 decap_w0
xfeed_9449 1 0 decap_w0
xfeed_9448 1 0 decap_w0
xfeed_8919 1 0 decap_w0
xfeed_8918 1 0 decap_w0
xfeed_8917 1 0 decap_w0
xfeed_8916 1 0 decap_w0
xfeed_8915 1 0 decap_w0
xfeed_8914 1 0 decap_w0
xfeed_8913 1 0 decap_w0
xfeed_8912 1 0 decap_w0
xfeed_8911 1 0 decap_w0
xfeed_8910 1 0 decap_w0
xfeed_4609 1 0 decap_w0
xfeed_3999 1 0 decap_w0
xfeed_3998 1 0 decap_w0
xfeed_3997 1 0 decap_w0
xfeed_3996 1 0 decap_w0
xfeed_3995 1 0 decap_w0
xfeed_3994 1 0 decap_w0
xfeed_3992 1 0 decap_w0
xfeed_3991 1 0 decap_w0
xfeed_3990 1 0 decap_w0
xsubckt_83_nexor2_x0 1 0 152 18 17 nexor2_x0
xsubckt_92_nexor2_x0 1 0 42 59 145 nexor2_x0
xfeed_25969 1 0 decap_w0
xfeed_25968 1 0 decap_w0
xfeed_25967 1 0 decap_w0
xfeed_25966 1 0 decap_w0
xfeed_25965 1 0 decap_w0
xfeed_19969 1 0 decap_w0
xfeed_19968 1 0 decap_w0
xfeed_19967 1 0 decap_w0
xfeed_19966 1 0 decap_w0
xfeed_19965 1 0 decap_w0
xfeed_19964 1 0 decap_w0
xfeed_19963 1 0 decap_w0
xfeed_19962 1 0 decap_w0
xfeed_19961 1 0 decap_w0
xfeed_19960 1 0 decap_w0
xfeed_16189 1 0 decap_w0
xfeed_16188 1 0 decap_w0
xfeed_16187 1 0 decap_w0
xfeed_16186 1 0 decap_w0
xfeed_16185 1 0 decap_w0
xfeed_16184 1 0 decap_w0
xfeed_16183 1 0 decap_w0
xfeed_16182 1 0 decap_w0
xfeed_16181 1 0 decap_w0
xfeed_16180 1 0 decap_w0
xfeed_15659 1 0 decap_w0
xfeed_15658 1 0 decap_w0
xfeed_15657 1 0 decap_w0
xfeed_15656 1 0 decap_w0
xfeed_15655 1 0 decap_w0
xfeed_15654 1 0 decap_w0
xfeed_15653 1 0 decap_w0
xfeed_15652 1 0 decap_w0
xfeed_15651 1 0 decap_w0
xfeed_15650 1 0 decap_w0
xfeed_11349 1 0 decap_w0
xfeed_11348 1 0 decap_w0
xfeed_11347 1 0 decap_w0
xfeed_11346 1 0 decap_w0
xfeed_11345 1 0 decap_w0
xfeed_11344 1 0 decap_w0
xfeed_11343 1 0 decap_w0
xfeed_11342 1 0 decap_w0
xfeed_11341 1 0 decap_w0
xfeed_11340 1 0 decap_w0
xfeed_10819 1 0 decap_w0
xfeed_10818 1 0 decap_w0
xfeed_10817 1 0 decap_w0
xfeed_10816 1 0 decap_w0
xfeed_10815 1 0 decap_w0
xfeed_10814 1 0 decap_w0
xfeed_10813 1 0 decap_w0
xfeed_10812 1 0 decap_w0
xfeed_10811 1 0 decap_w0
xfeed_10810 1 0 tie
xfeed_9454 1 0 decap_w0
xfeed_9453 1 0 decap_w0
xfeed_9452 1 0 decap_w0
xfeed_9451 1 0 decap_w0
xfeed_9450 1 0 decap_w0
xfeed_5149 1 0 decap_w0
xfeed_5148 1 0 decap_w0
xfeed_5147 1 0 decap_w0
xfeed_5146 1 0 decap_w0
xfeed_5145 1 0 decap_w0
xfeed_5144 1 0 decap_w0
xfeed_5143 1 0 decap_w0
xfeed_5142 1 0 decap_w0
xfeed_5141 1 0 decap_w0
xfeed_5140 1 0 decap_w0
xfeed_4615 1 0 decap_w0
xfeed_4614 1 0 decap_w0
xfeed_4613 1 0 decap_w0
xfeed_4612 1 0 decap_w0
xfeed_4611 1 0 decap_w0
xfeed_4610 1 0 decap_w0
xsubckt_74_nexor2_x0 1 0 159 160 158 nexor2_x0
xfeed_31979 1 0 decap_w0
xfeed_31978 1 0 decap_w0
xfeed_31977 1 0 decap_w0
xfeed_31976 1 0 decap_w0
xfeed_31975 1 0 decap_w0
xfeed_31974 1 0 decap_w0
xfeed_31973 1 0 decap_w0
xfeed_31972 1 0 decap_w0
xfeed_31971 1 0 decap_w0
xfeed_31970 1 0 decap_w0
xfeed_27119 1 0 decap_w0
xfeed_27118 1 0 decap_w0
xfeed_27117 1 0 decap_w0
xfeed_27116 1 0 decap_w0
xfeed_27115 1 0 decap_w0
xfeed_27114 1 0 decap_w0
xfeed_27113 1 0 decap_w0
xfeed_27112 1 0 decap_w0
xfeed_27111 1 0 decap_w0
xfeed_27110 1 0 decap_w0
xfeed_25971 1 0 decap_w0
xfeed_25970 1 0 decap_w0
xfeed_22199 1 0 decap_w0
xfeed_22198 1 0 decap_w0
xfeed_22197 1 0 decap_w0
xfeed_22196 1 0 decap_w0
xfeed_22195 1 0 decap_w0
xfeed_22194 1 0 decap_w0
xfeed_22193 1 0 decap_w0
xfeed_22192 1 0 decap_w0
xfeed_22191 1 0 decap_w0
xfeed_22190 1 0 decap_w0
xfeed_21669 1 0 decap_w0
xfeed_21668 1 0 decap_w0
xfeed_21667 1 0 decap_w0
xfeed_21666 1 0 decap_w0
xfeed_21665 1 0 decap_w0
xfeed_21664 1 0 decap_w0
xfeed_21663 1 0 decap_w0
xfeed_21662 1 0 decap_w0
xfeed_21661 1 0 decap_w0
xfeed_21660 1 0 decap_w0
xfeed_9459 1 0 decap_w0
xfeed_9458 1 0 decap_w0
xfeed_9457 1 0 decap_w0
xfeed_9456 1 0 decap_w0
xfeed_9455 1 0 decap_w0
xfeed_8929 1 0 decap_w0
xfeed_8928 1 0 decap_w0
xfeed_8927 1 0 decap_w0
xfeed_8926 1 0 decap_w0
xfeed_8925 1 0 decap_w0
xfeed_8924 1 0 decap_w0
xfeed_8923 1 0 decap_w0
xfeed_8922 1 0 decap_w0
xfeed_8921 1 0 decap_w0
xfeed_8920 1 0 decap_w0
xfeed_4619 1 0 decap_w0
xfeed_4618 1 0 decap_w0
xfeed_4617 1 0 decap_w0
xfeed_4616 1 0 decap_w0
xsubckt_65_nexor2_x0 1 0 35 57 165 nexor2_x0
xfeed_25979 1 0 decap_w0
xfeed_25978 1 0 decap_w0
xfeed_25977 1 0 decap_w0
xfeed_25976 1 0 decap_w0
xfeed_25975 1 0 decap_w0
xfeed_25974 1 0 decap_w0
xfeed_25973 1 0 decap_w0
xfeed_25972 1 0 decap_w0
xfeed_19979 1 0 decap_w0
xfeed_19978 1 0 decap_w0
xfeed_19977 1 0 decap_w0
xfeed_19976 1 0 decap_w0
xfeed_19975 1 0 decap_w0
xfeed_19974 1 0 tie
xfeed_19973 1 0 decap_w0
xfeed_19972 1 0 decap_w0
xfeed_19971 1 0 decap_w0
xfeed_19970 1 0 decap_w0
xfeed_16199 1 0 decap_w0
xfeed_16198 1 0 decap_w0
xfeed_16197 1 0 decap_w0
xfeed_16196 1 0 decap_w0
xfeed_16195 1 0 decap_w0
xfeed_16194 1 0 decap_w0
xfeed_16193 1 0 decap_w0
xfeed_16192 1 0 decap_w0
xfeed_16191 1 0 decap_w0
xfeed_16190 1 0 decap_w0
xfeed_15669 1 0 decap_w0
xfeed_15668 1 0 decap_w0
xfeed_15667 1 0 decap_w0
xfeed_15666 1 0 decap_w0
xfeed_15665 1 0 decap_w0
xfeed_15664 1 0 decap_w0
xfeed_15663 1 0 decap_w0
xfeed_15662 1 0 decap_w0
xfeed_15661 1 0 decap_w0
xfeed_15660 1 0 decap_w0
xfeed_11359 1 0 decap_w0
xfeed_11358 1 0 decap_w0
xfeed_11357 1 0 decap_w0
xfeed_11356 1 0 decap_w0
xfeed_11355 1 0 decap_w0
xfeed_11354 1 0 decap_w0
xfeed_11353 1 0 decap_w0
xfeed_11352 1 0 decap_w0
xfeed_11351 1 0 decap_w0
xfeed_11350 1 0 decap_w0
xfeed_10829 1 0 decap_w0
xfeed_10828 1 0 decap_w0
xfeed_10827 1 0 decap_w0
xfeed_10826 1 0 decap_w0
xfeed_10825 1 0 decap_w0
xfeed_10824 1 0 decap_w0
xfeed_10823 1 0 decap_w0
xfeed_10822 1 0 decap_w0
xfeed_10821 1 0 decap_w0
xfeed_10820 1 0 decap_w0
xfeed_9461 1 0 decap_w0
xfeed_9460 1 0 decap_w0
xfeed_5159 1 0 decap_w0
xfeed_5158 1 0 decap_w0
xfeed_5157 1 0 decap_w0
xfeed_5156 1 0 decap_w0
xfeed_5155 1 0 decap_w0
xfeed_5154 1 0 decap_w0
xfeed_5153 1 0 decap_w0
xfeed_5152 1 0 decap_w0
xfeed_5151 1 0 decap_w0
xfeed_5150 1 0 decap_w0
xfeed_4622 1 0 decap_w0
xfeed_4621 1 0 decap_w0
xfeed_4620 1 0 decap_w0
xsubckt_56_nexor2_x0 1 0 173 3 2 nexor2_x0
xfeed_31989 1 0 decap_w0
xfeed_31988 1 0 decap_w0
xfeed_31987 1 0 decap_w0
xfeed_31986 1 0 decap_w0
xfeed_31985 1 0 decap_w0
xfeed_31984 1 0 decap_w0
xfeed_31983 1 0 decap_w0
xfeed_31982 1 0 decap_w0
xfeed_31981 1 0 decap_w0
xfeed_31980 1 0 decap_w0
xfeed_27129 1 0 decap_w0
xfeed_27128 1 0 decap_w0
xfeed_27127 1 0 decap_w0
xfeed_27126 1 0 decap_w0
xfeed_27125 1 0 decap_w0
xfeed_27124 1 0 decap_w0
xfeed_27123 1 0 decap_w0
xfeed_27122 1 0 decap_w0
xfeed_27121 1 0 decap_w0
xfeed_27120 1 0 decap_w0
xfeed_21678 1 0 decap_w0
xfeed_21677 1 0 decap_w0
xfeed_21676 1 0 decap_w0
xfeed_21675 1 0 decap_w0
xfeed_21674 1 0 decap_w0
xfeed_21673 1 0 decap_w0
xfeed_21672 1 0 decap_w0
xfeed_21671 1 0 decap_w0
xfeed_21670 1 0 decap_w0
xfeed_9469 1 0 decap_w0
xfeed_9468 1 0 decap_w0
xfeed_9467 1 0 decap_w0
xfeed_9466 1 0 decap_w0
xfeed_9465 1 0 decap_w0
xfeed_9464 1 0 decap_w0
xfeed_9463 1 0 decap_w0
xfeed_9462 1 0 decap_w0
xfeed_8939 1 0 decap_w0
xfeed_8938 1 0 decap_w0
xfeed_8937 1 0 decap_w0
xfeed_8936 1 0 decap_w0
xfeed_8935 1 0 decap_w0
xfeed_8934 1 0 decap_w0
xfeed_8933 1 0 decap_w0
xfeed_8932 1 0 decap_w0
xfeed_8931 1 0 decap_w0
xfeed_8930 1 0 decap_w0
xfeed_4629 1 0 decap_w0
xfeed_4628 1 0 decap_w0
xfeed_4627 1 0 decap_w0
xfeed_4626 1 0 decap_w0
xfeed_4625 1 0 decap_w0
xfeed_4624 1 0 decap_w0
xfeed_4623 1 0 decap_w0
xsubckt_38_nexor2_x0 1 0 184 124 183 nexor2_x0
xfeed_25989 1 0 decap_w0
xfeed_25988 1 0 decap_w0
xfeed_25987 1 0 decap_w0
xfeed_25986 1 0 decap_w0
xfeed_25985 1 0 decap_w0
xfeed_25984 1 0 decap_w0
xfeed_25983 1 0 decap_w0
xfeed_25982 1 0 decap_w0
xfeed_25981 1 0 decap_w0
xfeed_25980 1 0 decap_w0
xfeed_21679 1 0 tie
xfeed_19989 1 0 decap_w0
xfeed_19988 1 0 decap_w0
xfeed_19987 1 0 decap_w0
xfeed_19986 1 0 decap_w0
xfeed_19985 1 0 decap_w0
xfeed_19984 1 0 decap_w0
xfeed_19983 1 0 decap_w0
xfeed_19982 1 0 decap_w0
xfeed_19981 1 0 decap_w0
xfeed_19980 1 0 decap_w0
xfeed_15679 1 0 decap_w0
xfeed_15678 1 0 decap_w0
xfeed_15677 1 0 decap_w0
xfeed_15676 1 0 decap_w0
xfeed_15675 1 0 decap_w0
xfeed_15674 1 0 decap_w0
xfeed_15673 1 0 decap_w0
xfeed_15672 1 0 decap_w0
xfeed_15671 1 0 decap_w0
xfeed_15670 1 0 decap_w0
xfeed_11369 1 0 decap_w0
xfeed_11368 1 0 decap_w0
xfeed_11367 1 0 decap_w0
xfeed_11366 1 0 decap_w0
xfeed_11365 1 0 decap_w0
xfeed_11364 1 0 decap_w0
xfeed_11363 1 0 decap_w0
xfeed_11362 1 0 decap_w0
xfeed_11361 1 0 decap_w0
xfeed_11360 1 0 decap_w0
xfeed_10839 1 0 decap_w0
xfeed_10838 1 0 decap_w0
xfeed_10837 1 0 decap_w0
xfeed_10836 1 0 decap_w0
xfeed_10835 1 0 decap_w0
xfeed_10834 1 0 decap_w0
xfeed_10833 1 0 decap_w0
xfeed_10832 1 0 decap_w0
xfeed_10831 1 0 decap_w0
xfeed_10830 1 0 decap_w0
xfeed_5168 1 0 decap_w0
xfeed_5167 1 0 decap_w0
xfeed_5166 1 0 decap_w0
xfeed_5165 1 0 decap_w0
xfeed_5164 1 0 decap_w0
xfeed_5163 1 0 decap_w0
xfeed_5162 1 0 decap_w0
xfeed_5161 1 0 decap_w0
xfeed_5160 1 0 decap_w0
xsubckt_29_nexor2_x0 1 0 120 29 119 nexor2_x0
xfeed_31999 1 0 decap_w0
xfeed_31998 1 0 decap_w0
xfeed_31997 1 0 decap_w0
xfeed_31996 1 0 decap_w0
xfeed_31995 1 0 decap_w0
xfeed_31994 1 0 decap_w0
xfeed_31993 1 0 decap_w0
xfeed_31992 1 0 decap_w0
xfeed_31991 1 0 decap_w0
xfeed_31990 1 0 decap_w0
xfeed_27139 1 0 decap_w0
xfeed_27138 1 0 decap_w0
xfeed_27137 1 0 decap_w0
xfeed_27136 1 0 decap_w0
xfeed_27135 1 0 decap_w0
xfeed_27134 1 0 decap_w0
xfeed_27133 1 0 decap_w0
xfeed_27132 1 0 decap_w0
xfeed_27131 1 0 decap_w0
xfeed_27130 1 0 decap_w0
xfeed_26609 1 0 decap_w0
xfeed_26608 1 0 decap_w0
xfeed_26607 1 0 decap_w0
xfeed_26606 1 0 decap_w0
xfeed_26605 1 0 decap_w0
xfeed_26604 1 0 decap_w0
xfeed_26603 1 0 decap_w0
xfeed_26602 1 0 decap_w0
xfeed_26601 1 0 decap_w0
xfeed_26600 1 0 decap_w0
xfeed_21685 1 0 decap_w0
xfeed_21684 1 0 decap_w0
xfeed_21683 1 0 decap_w0
xfeed_21682 1 0 decap_w0
xfeed_21681 1 0 decap_w0
xfeed_21680 1 0 decap_w0
xfeed_9479 1 0 decap_w0
xfeed_9478 1 0 decap_w0
xfeed_9477 1 0 decap_w0
xfeed_9476 1 0 decap_w0
xfeed_9475 1 0 decap_w0
xfeed_9474 1 0 decap_w0
xfeed_9473 1 0 decap_w0
xfeed_9472 1 0 decap_w0
xfeed_9471 1 0 decap_w0
xfeed_9470 1 0 decap_w0
xfeed_8949 1 0 decap_w0
xfeed_8948 1 0 decap_w0
xfeed_8947 1 0 decap_w0
xfeed_8946 1 0 decap_w0
xfeed_8945 1 0 decap_w0
xfeed_8944 1 0 decap_w0
xfeed_8943 1 0 decap_w0
xfeed_8942 1 0 decap_w0
xfeed_8941 1 0 decap_w0
xfeed_8940 1 0 decap_w0
xfeed_5169 1 0 decap_w0
xfeed_4639 1 0 decap_w0
xfeed_4638 1 0 decap_w0
xfeed_4637 1 0 decap_w0
xfeed_4636 1 0 decap_w0
xfeed_4635 1 0 decap_w0
xfeed_4634 1 0 decap_w0
xfeed_4633 1 0 decap_w0
xfeed_4632 1 0 decap_w0
xfeed_4631 1 0 decap_w0
xfeed_4630 1 0 decap_w0
xfeed_25999 1 0 decap_w0
xfeed_25998 1 0 decap_w0
xfeed_25997 1 0 decap_w0
xfeed_25996 1 0 decap_w0
xfeed_25995 1 0 decap_w0
xfeed_25994 1 0 decap_w0
xfeed_25993 1 0 decap_w0
xfeed_25992 1 0 decap_w0
xfeed_25991 1 0 decap_w0
xfeed_25990 1 0 decap_w0
xfeed_21689 1 0 decap_w0
xfeed_21688 1 0 decap_w0
xfeed_21687 1 0 decap_w0
xfeed_21686 1 0 decap_w0
xfeed_19999 1 0 decap_w0
xfeed_19998 1 0 decap_w0
xfeed_19997 1 0 decap_w0
xfeed_19996 1 0 decap_w0
xfeed_19995 1 0 decap_w0
xfeed_19994 1 0 decap_w0
xfeed_19993 1 0 decap_w0
xfeed_19992 1 0 decap_w0
xfeed_19991 1 0 decap_w0
xfeed_19990 1 0 decap_w0
xfeed_15689 1 0 decap_w0
xfeed_15688 1 0 decap_w0
xfeed_15687 1 0 decap_w0
xfeed_15686 1 0 decap_w0
xfeed_15685 1 0 decap_w0
xfeed_15684 1 0 decap_w0
xfeed_15683 1 0 decap_w0
xfeed_15682 1 0 decap_w0
xfeed_15681 1 0 decap_w0
xfeed_15680 1 0 decap_w0
xfeed_11379 1 0 decap_w0
xfeed_11378 1 0 decap_w0
xfeed_11377 1 0 decap_w0
xfeed_11376 1 0 decap_w0
xfeed_11375 1 0 decap_w0
xfeed_11374 1 0 decap_w0
xfeed_11373 1 0 decap_w0
xfeed_11372 1 0 decap_w0
xfeed_11371 1 0 decap_w0
xfeed_11370 1 0 decap_w0
xfeed_10849 1 0 decap_w0
xfeed_10848 1 0 decap_w0
xfeed_10847 1 0 decap_w0
xfeed_10846 1 0 decap_w0
xfeed_10845 1 0 decap_w0
xfeed_10844 1 0 decap_w0
xfeed_10843 1 0 decap_w0
xfeed_10842 1 0 decap_w0
xfeed_10841 1 0 decap_w0
xfeed_10840 1 0 decap_w0
xfeed_5175 1 0 decap_w0
xfeed_5174 1 0 decap_w0
xfeed_5173 1 0 decap_w0
xfeed_5172 1 0 decap_w0
xfeed_5171 1 0 decap_w0
xfeed_5170 1 0 decap_w0
xfeed_27149 1 0 decap_w0
xfeed_27148 1 0 decap_w0
xfeed_27147 1 0 decap_w0
xfeed_27146 1 0 decap_w0
xfeed_27145 1 0 decap_w0
xfeed_27144 1 0 decap_w0
xfeed_27143 1 0 decap_w0
xfeed_27142 1 0 decap_w0
xfeed_27141 1 0 decap_w0
xfeed_27140 1 0 decap_w0
xfeed_26619 1 0 decap_w0
xfeed_26618 1 0 decap_w0
xfeed_26617 1 0 decap_w0
xfeed_26616 1 0 tie
xfeed_26615 1 0 decap_w0
xfeed_26614 1 0 decap_w0
xfeed_26613 1 0 decap_w0
xfeed_26612 1 0 decap_w0
xfeed_26611 1 0 decap_w0
xfeed_26610 1 0 decap_w0
xfeed_22309 1 0 decap_w0
xfeed_22308 1 0 decap_w0
xfeed_22307 1 0 decap_w0
xfeed_22306 1 0 decap_w0
xfeed_22305 1 0 decap_w0
xfeed_22304 1 0 decap_w0
xfeed_22303 1 0 decap_w0
xfeed_22302 1 0 decap_w0
xfeed_22301 1 0 decap_w0
xfeed_22300 1 0 decap_w0
xfeed_21692 1 0 decap_w0
xfeed_21691 1 0 decap_w0
xfeed_21690 1 0 decap_w0
xfeed_16302 1 0 decap_w0
xfeed_16301 1 0 decap_w0
xfeed_16300 1 0 decap_w0
xfeed_9489 1 0 decap_w0
xfeed_9488 1 0 decap_w0
xfeed_9487 1 0 decap_w0
xfeed_9486 1 0 decap_w0
xfeed_9485 1 0 decap_w0
xfeed_9484 1 0 decap_w0
xfeed_9483 1 0 decap_w0
xfeed_9482 1 0 decap_w0
xfeed_9481 1 0 decap_w0
xfeed_9480 1 0 decap_w0
xfeed_8959 1 0 decap_w0
xfeed_8958 1 0 decap_w0
xfeed_8957 1 0 decap_w0
xfeed_8956 1 0 decap_w0
xfeed_8955 1 0 decap_w0
xfeed_8954 1 0 decap_w0
xfeed_8953 1 0 decap_w0
xfeed_8952 1 0 decap_w0
xfeed_8951 1 0 decap_w0
xfeed_8950 1 0 decap_w0
xfeed_5179 1 0 decap_w0
xfeed_5178 1 0 decap_w0
xfeed_5177 1 0 decap_w0
xfeed_5176 1 0 decap_w0
xfeed_4649 1 0 decap_w0
xfeed_4648 1 0 decap_w0
xfeed_4646 1 0 decap_w0
xfeed_4645 1 0 decap_w0
xfeed_4644 1 0 decap_w0
xfeed_4643 1 0 decap_w0
xfeed_4642 1 0 decap_w0
xfeed_4641 1 0 decap_w0
xfeed_4640 1 0 decap_w0
xsubckt_89_nexor2_x0 1 0 148 170 147 nexor2_x0
xsubckt_98_nexor2_x0 1 0 141 147 140 nexor2_x0
xfeed_21699 1 0 decap_w0
xfeed_21698 1 0 decap_w0
xfeed_21697 1 0 decap_w0
xfeed_21696 1 0 decap_w0
xfeed_21695 1 0 decap_w0
xfeed_21694 1 0 decap_w0
xfeed_21693 1 0 decap_w0
xfeed_16309 1 0 decap_w0
xfeed_16308 1 0 decap_w0
xfeed_16307 1 0 decap_w0
xfeed_16306 1 0 decap_w0
xfeed_16305 1 0 decap_w0
xfeed_16304 1 0 decap_w0
xfeed_16303 1 0 decap_w0
xfeed_15699 1 0 decap_w0
xfeed_15698 1 0 decap_w0
xfeed_15697 1 0 decap_w0
xfeed_15696 1 0 decap_w0
xfeed_15695 1 0 decap_w0
xfeed_15694 1 0 decap_w0
xfeed_15693 1 0 decap_w0
xfeed_15692 1 0 decap_w0
xfeed_15691 1 0 decap_w0
xfeed_15690 1 0 decap_w0
xfeed_11389 1 0 decap_w0
xfeed_11387 1 0 decap_w0
xfeed_11386 1 0 decap_w0
xfeed_11385 1 0 decap_w0
xfeed_11384 1 0 decap_w0
xfeed_11383 1 0 decap_w0
xfeed_11382 1 0 decap_w0
xfeed_11381 1 0 decap_w0
xfeed_11380 1 0 decap_w0
xfeed_10859 1 0 decap_w0
xfeed_10858 1 0 decap_w0
xfeed_10857 1 0 decap_w0
xfeed_10856 1 0 decap_w0
xfeed_10855 1 0 decap_w0
xfeed_10854 1 0 decap_w0
xfeed_10853 1 0 decap_w0
xfeed_10852 1 0 decap_w0
xfeed_10851 1 0 decap_w0
xfeed_10850 1 0 decap_w0
xfeed_5182 1 0 decap_w0
xfeed_5181 1 0 decap_w0
xfeed_5180 1 0 decap_w0
xfeed_27159 1 0 decap_w0
xfeed_27158 1 0 decap_w0
xfeed_27157 1 0 decap_w0
xfeed_27156 1 0 decap_w0
xfeed_27155 1 0 decap_w0
xfeed_27154 1 0 decap_w0
xfeed_27153 1 0 decap_w0
xfeed_27152 1 0 decap_w0
xfeed_27151 1 0 decap_w0
xfeed_27150 1 0 decap_w0
xfeed_26629 1 0 decap_w0
xfeed_26628 1 0 decap_w0
xfeed_26627 1 0 decap_w0
xfeed_26626 1 0 decap_w0
xfeed_26625 1 0 decap_w0
xfeed_26624 1 0 decap_w0
xfeed_26623 1 0 decap_w0
xfeed_26622 1 0 decap_w0
xfeed_26621 1 0 decap_w0
xfeed_26620 1 0 decap_w0
xfeed_22319 1 0 decap_w0
xfeed_22318 1 0 decap_w0
xfeed_22317 1 0 decap_w0
xfeed_22316 1 0 decap_w0
xfeed_22315 1 0 decap_w0
xfeed_22314 1 0 decap_w0
xfeed_22313 1 0 decap_w0
xfeed_22312 1 0 decap_w0
xfeed_22311 1 0 decap_w0
xfeed_22310 1 0 decap_w0
xfeed_12009 1 0 decap_w0
xfeed_12008 1 0 decap_w0
xfeed_12007 1 0 decap_w0
xfeed_12006 1 0 decap_w0
xfeed_12005 1 0 decap_w0
xfeed_12004 1 0 decap_w0
xfeed_12003 1 0 tie
xfeed_12002 1 0 decap_w0
xfeed_12001 1 0 decap_w0
xfeed_12000 1 0 decap_w0
xfeed_9499 1 0 decap_w0
xfeed_9498 1 0 decap_w0
xfeed_9497 1 0 decap_w0
xfeed_9496 1 0 decap_w0
xfeed_9495 1 0 decap_w0
xfeed_9494 1 0 decap_w0
xfeed_9493 1 0 decap_w0
xfeed_9492 1 0 decap_w0
xfeed_9491 1 0 decap_w0
xfeed_9490 1 0 decap_w0
xfeed_8969 1 0 decap_w0
xfeed_8968 1 0 decap_w0
xfeed_8967 1 0 decap_w0
xfeed_8966 1 0 decap_w0
xfeed_8965 1 0 decap_w0
xfeed_8964 1 0 decap_w0
xfeed_8963 1 0 decap_w0
xfeed_8962 1 0 decap_w0
xfeed_8961 1 0 decap_w0
xfeed_8960 1 0 decap_w0
xfeed_5189 1 0 decap_w0
xfeed_5188 1 0 decap_w0
xfeed_5187 1 0 decap_w0
xfeed_5186 1 0 decap_w0
xfeed_5185 1 0 decap_w0
xfeed_5184 1 0 decap_w0
xfeed_5183 1 0 decap_w0
xfeed_4659 1 0 decap_w0
xfeed_4658 1 0 decap_w0
xfeed_4657 1 0 decap_w0
xfeed_4656 1 0 decap_w0
xfeed_4655 1 0 decap_w0
xfeed_4654 1 0 decap_w0
xfeed_4653 1 0 decap_w0
xfeed_4652 1 0 decap_w0
xfeed_4651 1 0 decap_w0
xfeed_4650 1 0 decap_w0
xfeed_16319 1 0 decap_w0
xfeed_16318 1 0 decap_w0
xfeed_16317 1 0 decap_w0
xfeed_16316 1 0 decap_w0
xfeed_16315 1 0 decap_w0
xfeed_16314 1 0 decap_w0
xfeed_16313 1 0 decap_w0
xfeed_16312 1 0 decap_w0
xfeed_16311 1 0 decap_w0
xfeed_16310 1 0 decap_w0
xfeed_11399 1 0 decap_w0
xfeed_11398 1 0 decap_w0
xfeed_11397 1 0 decap_w0
xfeed_11396 1 0 decap_w0
xfeed_11395 1 0 decap_w0
xfeed_11394 1 0 decap_w0
xfeed_11393 1 0 decap_w0
xfeed_11392 1 0 decap_w0
xfeed_11391 1 0 decap_w0
xfeed_11390 1 0 decap_w0
xfeed_10869 1 0 decap_w0
xfeed_10868 1 0 decap_w0
xfeed_10867 1 0 decap_w0
xfeed_10866 1 0 decap_w0
xfeed_10865 1 0 decap_w0
xfeed_10864 1 0 decap_w0
xfeed_10863 1 0 decap_w0
xfeed_10862 1 0 decap_w0
xfeed_10861 1 0 decap_w0
xfeed_10860 1 0 decap_w0
xsubckt_7_xor2_x0 1 0 38 64 7 xor2_x0
xfeed_27169 1 0 decap_w0
xfeed_27168 1 0 decap_w0
xfeed_27167 1 0 decap_w0
xfeed_27166 1 0 decap_w0
xfeed_27165 1 0 decap_w0
xfeed_27164 1 0 decap_w0
xfeed_27163 1 0 decap_w0
xfeed_27162 1 0 decap_w0
xfeed_27161 1 0 decap_w0
xfeed_27160 1 0 decap_w0
xfeed_26639 1 0 decap_w0
xfeed_26638 1 0 decap_w0
xfeed_26637 1 0 decap_w0
xfeed_26636 1 0 decap_w0
xfeed_26635 1 0 decap_w0
xfeed_26634 1 0 decap_w0
xfeed_26633 1 0 decap_w0
xfeed_26632 1 0 decap_w0
xfeed_26631 1 0 decap_w0
xfeed_26630 1 0 decap_w0
xfeed_22329 1 0 decap_w0
xfeed_22328 1 0 decap_w0
xfeed_22327 1 0 decap_w0
xfeed_22326 1 0 decap_w0
xfeed_22325 1 0 decap_w0
xfeed_22324 1 0 decap_w0
xfeed_22323 1 0 decap_w0
xfeed_22322 1 0 decap_w0
xfeed_22321 1 0 decap_w0
xfeed_22320 1 0 decap_w0
xfeed_12016 1 0 decap_w0
xfeed_12015 1 0 decap_w0
xfeed_12014 1 0 decap_w0
xfeed_12013 1 0 decap_w0
xfeed_12012 1 0 decap_w0
xfeed_12011 1 0 decap_w0
xfeed_12010 1 0 decap_w0
xfeed_8979 1 0 decap_w0
xfeed_8978 1 0 decap_w0
xfeed_8977 1 0 decap_w0
xfeed_8976 1 0 decap_w0
xfeed_8975 1 0 decap_w0
xfeed_8974 1 0 decap_w0
xfeed_8973 1 0 decap_w0
xfeed_8972 1 0 decap_w0
xfeed_8971 1 0 decap_w0
xfeed_8970 1 0 decap_w0
xfeed_5199 1 0 decap_w0
xfeed_5198 1 0 decap_w0
xfeed_5197 1 0 decap_w0
xfeed_5196 1 0 decap_w0
xfeed_5195 1 0 decap_w0
xfeed_5194 1 0 decap_w0
xfeed_5193 1 0 decap_w0
xfeed_5192 1 0 decap_w0
xfeed_5191 1 0 decap_w0
xfeed_5190 1 0 decap_w0
xfeed_4669 1 0 decap_w0
xfeed_4668 1 0 decap_w0
xfeed_4667 1 0 decap_w0
xfeed_4666 1 0 decap_w0
xfeed_4665 1 0 decap_w0
xfeed_4664 1 0 decap_w0
xfeed_4663 1 0 decap_w0
xfeed_4662 1 0 decap_w0
xfeed_4661 1 0 decap_w0
xfeed_4660 1 0 decap_w0
xfeed_16329 1 0 decap_w0
xfeed_16328 1 0 decap_w0
xfeed_16327 1 0 decap_w0
xfeed_16326 1 0 decap_w0
xfeed_16325 1 0 decap_w0
xfeed_16324 1 0 decap_w0
xfeed_16323 1 0 decap_w0
xfeed_16322 1 0 decap_w0
xfeed_16321 1 0 decap_w0
xfeed_16320 1 0 decap_w0
xfeed_12019 1 0 decap_w0
xfeed_12018 1 0 decap_w0
xfeed_12017 1 0 decap_w0
xfeed_10879 1 0 decap_w0
xfeed_10878 1 0 decap_w0
xfeed_10877 1 0 decap_w0
xfeed_10876 1 0 decap_w0
xfeed_10875 1 0 decap_w0
xfeed_10874 1 0 decap_w0
xfeed_10873 1 0 decap_w0
xfeed_10872 1 0 decap_w0
xfeed_10871 1 0 decap_w0
xfeed_10870 1 0 decap_w0
xfeed_27179 1 0 decap_w0
xfeed_27178 1 0 decap_w0
xfeed_27177 1 0 decap_w0
xfeed_27176 1 0 decap_w0
xfeed_27175 1 0 decap_w0
xfeed_27174 1 0 decap_w0
xfeed_27173 1 0 decap_w0
xfeed_27172 1 0 decap_w0
xfeed_27171 1 0 decap_w0
xfeed_27170 1 0 decap_w0
xfeed_26649 1 0 decap_w0
xfeed_26648 1 0 decap_w0
xfeed_26647 1 0 decap_w0
xfeed_26646 1 0 decap_w0
xfeed_26645 1 0 decap_w0
xfeed_26644 1 0 decap_w0
xfeed_26643 1 0 decap_w0
xfeed_26642 1 0 decap_w0
xfeed_26641 1 0 decap_w0
xfeed_26640 1 0 decap_w0
xfeed_22339 1 0 decap_w0
xfeed_22338 1 0 decap_w0
xfeed_22337 1 0 decap_w0
xfeed_22336 1 0 decap_w0
xfeed_22335 1 0 decap_w0
xfeed_22334 1 0 decap_w0
xfeed_22333 1 0 decap_w0
xfeed_22332 1 0 decap_w0
xfeed_22331 1 0 decap_w0
xfeed_22330 1 0 decap_w0
xfeed_21809 1 0 decap_w0
xfeed_21808 1 0 decap_w0
xfeed_21807 1 0 decap_w0
xfeed_21806 1 0 decap_w0
xfeed_21805 1 0 decap_w0
xfeed_21804 1 0 decap_w0
xfeed_21803 1 0 decap_w0
xfeed_21802 1 0 decap_w0
xfeed_21801 1 0 decap_w0
xfeed_21800 1 0 decap_w0
xfeed_12023 1 0 decap_w0
xfeed_12022 1 0 decap_w0
xfeed_12021 1 0 decap_w0
xfeed_12020 1 0 decap_w0
xfeed_8989 1 0 decap_w0
xfeed_8988 1 0 decap_w0
xfeed_8987 1 0 decap_w0
xfeed_8986 1 0 decap_w0
xfeed_8985 1 0 decap_w0
xfeed_8984 1 0 decap_w0
xfeed_8983 1 0 decap_w0
xfeed_8982 1 0 decap_w0
xfeed_8981 1 0 decap_w0
xfeed_8980 1 0 decap_w0
xfeed_4679 1 0 decap_w0
xfeed_4678 1 0 decap_w0
xfeed_4677 1 0 decap_w0
xfeed_4676 1 0 decap_w0
xfeed_4675 1 0 decap_w0
xfeed_4674 1 0 decap_w0
xfeed_4673 1 0 decap_w0
xfeed_4672 1 0 decap_w0
xfeed_4671 1 0 decap_w0
xfeed_4670 1 0 decap_w0
xfeed_16339 1 0 decap_w0
xfeed_16338 1 0 decap_w0
xfeed_16337 1 0 decap_w0
xfeed_16336 1 0 decap_w0
xfeed_16335 1 0 decap_w0
xfeed_16334 1 0 decap_w0
xfeed_16333 1 0 decap_w0
xfeed_16332 1 0 decap_w0
xfeed_16331 1 0 decap_w0
xfeed_16330 1 0 decap_w0
xfeed_15809 1 0 decap_w0
xfeed_15808 1 0 decap_w0
xfeed_15807 1 0 decap_w0
xfeed_15806 1 0 decap_w0
xfeed_15805 1 0 decap_w0
xfeed_15804 1 0 decap_w0
xfeed_15803 1 0 decap_w0
xfeed_15802 1 0 decap_w0
xfeed_15801 1 0 decap_w0
xfeed_15800 1 0 decap_w0
xfeed_12029 1 0 decap_w0
xfeed_12028 1 0 decap_w0
xfeed_12027 1 0 decap_w0
xfeed_12026 1 0 decap_w0
xfeed_12025 1 0 decap_w0
xfeed_12024 1 0 decap_w0
xfeed_10889 1 0 decap_w0
xfeed_10888 1 0 decap_w0
xfeed_10887 1 0 decap_w0
xfeed_10886 1 0 decap_w0
xfeed_10885 1 0 decap_w0
xfeed_10884 1 0 decap_w0
xfeed_10883 1 0 decap_w0
xfeed_10882 1 0 decap_w0
xfeed_10881 1 0 decap_w0
xfeed_10880 1 0 decap_w0
xfeed_9601 1 0 decap_w0
xfeed_9600 1 0 decap_w0
xfeed_27189 1 0 decap_w0
xfeed_27188 1 0 decap_w0
xfeed_27187 1 0 decap_w0
xfeed_27186 1 0 decap_w0
xfeed_27185 1 0 decap_w0
xfeed_27184 1 0 decap_w0
xfeed_27183 1 0 decap_w0
xfeed_27182 1 0 decap_w0
xfeed_27181 1 0 decap_w0
xfeed_27180 1 0 decap_w0
xfeed_26657 1 0 decap_w0
xfeed_26656 1 0 decap_w0
xfeed_26655 1 0 decap_w0
xfeed_26654 1 0 decap_w0
xfeed_26653 1 0 decap_w0
xfeed_26652 1 0 decap_w0
xfeed_26651 1 0 decap_w0
xfeed_26650 1 0 decap_w0
xfeed_22349 1 0 decap_w0
xfeed_22348 1 0 decap_w0
xfeed_22347 1 0 decap_w0
xfeed_22346 1 0 decap_w0
xfeed_22345 1 0 decap_w0
xfeed_22344 1 0 decap_w0
xfeed_22343 1 0 decap_w0
xfeed_22342 1 0 decap_w0
xfeed_22341 1 0 decap_w0
xfeed_22340 1 0 decap_w0
xfeed_21818 1 0 decap_w0
xfeed_21817 1 0 decap_w0
xfeed_21816 1 0 decap_w0
xfeed_21815 1 0 decap_w0
xfeed_21814 1 0 decap_w0
xfeed_21813 1 0 decap_w0
xfeed_21812 1 0 decap_w0
xfeed_21811 1 0 decap_w0
xfeed_21810 1 0 decap_w0
xfeed_12030 1 0 decap_w0
xfeed_9609 1 0 decap_w0
xfeed_9608 1 0 decap_w0
xfeed_9607 1 0 decap_w0
xfeed_9606 1 0 decap_w0
xfeed_9605 1 0 decap_w0
xfeed_9604 1 0 decap_w0
xfeed_9603 1 0 decap_w0
xfeed_9602 1 0 decap_w0
xfeed_8999 1 0 decap_w0
xfeed_8998 1 0 decap_w0
xfeed_8997 1 0 decap_w0
xfeed_8996 1 0 decap_w0
xfeed_8995 1 0 decap_w0
xfeed_8994 1 0 decap_w0
xfeed_8993 1 0 decap_w0
xfeed_8992 1 0 decap_w0
xfeed_8991 1 0 decap_w0
xfeed_8990 1 0 decap_w0
xfeed_4689 1 0 decap_w0
xfeed_4688 1 0 decap_w0
xfeed_4687 1 0 decap_w0
xfeed_4686 1 0 decap_w0
xfeed_4685 1 0 decap_w0
xfeed_4684 1 0 decap_w0
xfeed_4683 1 0 decap_w0
xfeed_4682 1 0 decap_w0
xfeed_4681 1 0 decap_w0
xfeed_4680 1 0 decap_w0
xfeed_26659 1 0 decap_w0
xfeed_26658 1 0 decap_w0
xfeed_21819 1 0 decap_w0
xfeed_16349 1 0 decap_w0
xfeed_16348 1 0 decap_w0
xfeed_16347 1 0 decap_w0
xfeed_16346 1 0 decap_w0
xfeed_16345 1 0 decap_w0
xfeed_16344 1 0 decap_w0
xfeed_16343 1 0 decap_w0
xfeed_16342 1 0 decap_w0
xfeed_16341 1 0 decap_w0
xfeed_16340 1 0 decap_w0
xfeed_15819 1 0 decap_w0
xfeed_15818 1 0 decap_w0
xfeed_15817 1 0 decap_w0
xfeed_15816 1 0 decap_w0
xfeed_15815 1 0 decap_w0
xfeed_15814 1 0 decap_w0
xfeed_15813 1 0 decap_w0
xfeed_15812 1 0 decap_w0
xfeed_15811 1 0 decap_w0
xfeed_15810 1 0 decap_w0
xfeed_12039 1 0 decap_w0
xfeed_12038 1 0 decap_w0
xfeed_12037 1 0 decap_w0
xfeed_12036 1 0 decap_w0
xfeed_12035 1 0 decap_w0
xfeed_12034 1 0 decap_w0
xfeed_12033 1 0 decap_w0
xfeed_12032 1 0 decap_w0
xfeed_12031 1 0 decap_w0
xfeed_11509 1 0 decap_w0
xfeed_11508 1 0 decap_w0
xfeed_11507 1 0 decap_w0
xfeed_11506 1 0 decap_w0
xfeed_11505 1 0 decap_w0
xfeed_11504 1 0 decap_w0
xfeed_11503 1 0 decap_w0
xfeed_11502 1 0 decap_w0
xfeed_11501 1 0 decap_w0
xfeed_11500 1 0 decap_w0
xfeed_10899 1 0 decap_w0
xfeed_10898 1 0 decap_w0
xfeed_10897 1 0 decap_w0
xfeed_10896 1 0 decap_w0
xfeed_10895 1 0 decap_w0
xfeed_10894 1 0 decap_w0
xfeed_10893 1 0 decap_w0
xfeed_10892 1 0 decap_w0
xfeed_10891 1 0 decap_w0
xfeed_10890 1 0 decap_w0
xfeed_5308 1 0 decap_w0
xfeed_5307 1 0 decap_w0
xfeed_5306 1 0 decap_w0
xfeed_5305 1 0 decap_w0
xfeed_5304 1 0 decap_w0
xfeed_5303 1 0 decap_w0
xfeed_5302 1 0 decap_w0
xfeed_5301 1 0 decap_w0
xfeed_5300 1 0 decap_w0
xfeed_27199 1 0 decap_w0
xfeed_27198 1 0 decap_w0
xfeed_27197 1 0 decap_w0
xfeed_27196 1 0 decap_w0
xfeed_27195 1 0 decap_w0
xfeed_27194 1 0 decap_w0
xfeed_27193 1 0 decap_w0
xfeed_27192 1 0 decap_w0
xfeed_27191 1 0 decap_w0
xfeed_27190 1 0 decap_w0
xfeed_26664 1 0 decap_w0
xfeed_26663 1 0 decap_w0
xfeed_26662 1 0 decap_w0
xfeed_26661 1 0 decap_w0
xfeed_26660 1 0 decap_w0
xfeed_22359 1 0 decap_w0
xfeed_22358 1 0 decap_w0
xfeed_22357 1 0 decap_w0
xfeed_22356 1 0 decap_w0
xfeed_22355 1 0 decap_w0
xfeed_22354 1 0 decap_w0
xfeed_22353 1 0 decap_w0
xfeed_22352 1 0 decap_w0
xfeed_22351 1 0 decap_w0
xfeed_22350 1 0 decap_w0
xfeed_21825 1 0 decap_w0
xfeed_21824 1 0 decap_w0
xfeed_21823 1 0 decap_w0
xfeed_21822 1 0 decap_w0
xfeed_21821 1 0 decap_w0
xfeed_21820 1 0 decap_w0
xfeed_9619 1 0 decap_w0
xfeed_9618 1 0 decap_w0
xfeed_9617 1 0 decap_w0
xfeed_9616 1 0 decap_w0
xfeed_9615 1 0 decap_w0
xfeed_9614 1 0 decap_w0
xfeed_9613 1 0 decap_w0
xfeed_9612 1 0 decap_w0
xfeed_9611 1 0 decap_w0
xfeed_9610 1 0 decap_w0
xfeed_5309 1 0 decap_w0
xfeed_4699 1 0 decap_w0
xfeed_4698 1 0 decap_w0
xfeed_4697 1 0 decap_w0
xfeed_4696 1 0 decap_w0
xfeed_4695 1 0 decap_w0
xfeed_4694 1 0 decap_w0
xfeed_4693 1 0 decap_w0
xfeed_4692 1 0 decap_w0
xfeed_4691 1 0 decap_w0
xfeed_4690 1 0 decap_w0
xfeed_26669 1 0 decap_w0
xfeed_26668 1 0 decap_w0
xfeed_26667 1 0 decap_w0
xfeed_26666 1 0 decap_w0
xfeed_26665 1 0 decap_w0
xfeed_21829 1 0 decap_w0
xfeed_21828 1 0 decap_w0
xfeed_21827 1 0 decap_w0
xfeed_21826 1 0 decap_w0
xfeed_16359 1 0 decap_w0
xfeed_16358 1 0 decap_w0
xfeed_16357 1 0 decap_w0
xfeed_16356 1 0 decap_w0
xfeed_16355 1 0 decap_w0
xfeed_16354 1 0 decap_w0
xfeed_16353 1 0 decap_w0
xfeed_16352 1 0 decap_w0
xfeed_16351 1 0 decap_w0
xfeed_16350 1 0 decap_w0
xfeed_15829 1 0 decap_w0
xfeed_15828 1 0 decap_w0
xfeed_15827 1 0 decap_w0
xfeed_15826 1 0 decap_w0
xfeed_15825 1 0 decap_w0
xfeed_15824 1 0 decap_w0
xfeed_15823 1 0 decap_w0
xfeed_15822 1 0 decap_w0
xfeed_15821 1 0 decap_w0
xfeed_15820 1 0 decap_w0
xfeed_12049 1 0 decap_w0
xfeed_12048 1 0 decap_w0
xfeed_12047 1 0 decap_w0
xfeed_12046 1 0 decap_w0
xfeed_12045 1 0 decap_w0
xfeed_12044 1 0 decap_w0
xfeed_12043 1 0 decap_w0
xfeed_12042 1 0 decap_w0
xfeed_12041 1 0 decap_w0
xfeed_12040 1 0 decap_w0
xfeed_11519 1 0 decap_w0
xfeed_11518 1 0 decap_w0
xfeed_11517 1 0 decap_w0
xfeed_11516 1 0 decap_w0
xfeed_11515 1 0 decap_w0
xfeed_11514 1 0 decap_w0
xfeed_11513 1 0 decap_w0
xfeed_11512 1 0 decap_w0
xfeed_11511 1 0 decap_w0
xfeed_11510 1 0 decap_w0
xfeed_5315 1 0 decap_w0
xfeed_5314 1 0 decap_w0
xfeed_5313 1 0 decap_w0
xfeed_5312 1 0 decap_w0
xfeed_5311 1 0 decap_w0
xfeed_5310 1 0 decap_w0
xfeed_1000 1 0 decap_w0
xfeed_1001 1 0 decap_w0
xfeed_1002 1 0 decap_w0
xfeed_1003 1 0 decap_w0
xfeed_1004 1 0 decap_w0
xfeed_1005 1 0 decap_w0
xfeed_1006 1 0 decap_w0
xfeed_1007 1 0 decap_w0
xfeed_1008 1 0 decap_w0
xfeed_1009 1 0 decap_w0
xfeed_26671 1 0 decap_w0
xfeed_26670 1 0 decap_w0
xfeed_22369 1 0 decap_w0
xfeed_22368 1 0 decap_w0
xfeed_22367 1 0 decap_w0
xfeed_22366 1 0 decap_w0
xfeed_22365 1 0 decap_w0
xfeed_22364 1 0 decap_w0
xfeed_22363 1 0 decap_w0
xfeed_22362 1 0 decap_w0
xfeed_22361 1 0 decap_w0
xfeed_22360 1 0 decap_w0
xfeed_21832 1 0 decap_w0
xfeed_21831 1 0 decap_w0
xfeed_21830 1 0 decap_w0
xfeed_9629 1 0 decap_w0
xfeed_9628 1 0 decap_w0
xfeed_9627 1 0 decap_w0
xfeed_9626 1 0 decap_w0
xfeed_9625 1 0 decap_w0
xfeed_9624 1 0 decap_w0
xfeed_9623 1 0 decap_w0
xfeed_9622 1 0 decap_w0
xfeed_9621 1 0 decap_w0
xfeed_9620 1 0 decap_w0
xfeed_5319 1 0 decap_w0
xfeed_5318 1 0 decap_w0
xfeed_5317 1 0 decap_w0
xfeed_5316 1 0 decap_w0
xfeed_26679 1 0 decap_w0
xfeed_26678 1 0 decap_w0
xfeed_26677 1 0 decap_w0
xfeed_26676 1 0 decap_w0
xfeed_26675 1 0 decap_w0
xfeed_26674 1 0 decap_w0
xfeed_26673 1 0 decap_w0
xfeed_26672 1 0 decap_w0
xfeed_21839 1 0 decap_w0
xfeed_21838 1 0 decap_w0
xfeed_21837 1 0 decap_w0
xfeed_21836 1 0 decap_w0
xfeed_21835 1 0 decap_w0
xfeed_21834 1 0 decap_w0
xfeed_21833 1 0 decap_w0
xfeed_16369 1 0 decap_w0
xfeed_16368 1 0 decap_w0
xfeed_16367 1 0 decap_w0
xfeed_16366 1 0 decap_w0
xfeed_16365 1 0 decap_w0
xfeed_16364 1 0 decap_w0
xfeed_16363 1 0 decap_w0
xfeed_16362 1 0 decap_w0
xfeed_16361 1 0 decap_w0
xfeed_16360 1 0 decap_w0
xfeed_15839 1 0 decap_w0
xfeed_15838 1 0 decap_w0
xfeed_15837 1 0 decap_w0
xfeed_15836 1 0 decap_w0
xfeed_15835 1 0 decap_w0
xfeed_15834 1 0 decap_w0
xfeed_15833 1 0 decap_w0
xfeed_15832 1 0 decap_w0
xfeed_15831 1 0 decap_w0
xfeed_15830 1 0 decap_w0
xfeed_12059 1 0 decap_w0
xfeed_12058 1 0 decap_w0
xfeed_12057 1 0 decap_w0
xfeed_12056 1 0 decap_w0
xfeed_12055 1 0 decap_w0
xfeed_12054 1 0 decap_w0
xfeed_12053 1 0 decap_w0
xfeed_12052 1 0 decap_w0
xfeed_12051 1 0 decap_w0
xfeed_12050 1 0 decap_w0
xfeed_11529 1 0 decap_w0
xfeed_11528 1 0 decap_w0
xfeed_11527 1 0 decap_w0
xfeed_11526 1 0 decap_w0
xfeed_11525 1 0 decap_w0
xfeed_11524 1 0 decap_w0
xfeed_11523 1 0 decap_w0
xfeed_11522 1 0 decap_w0
xfeed_11521 1 0 decap_w0
xfeed_11520 1 0 decap_w0
xfeed_5322 1 0 decap_w0
xfeed_5321 1 0 decap_w0
xfeed_5320 1 0 decap_w0
xfeed_1010 1 0 decap_w0
xfeed_1011 1 0 decap_w0
xfeed_1012 1 0 decap_w0
xfeed_1013 1 0 decap_w0
xfeed_1014 1 0 decap_w0
xfeed_1015 1 0 decap_w0
xfeed_1016 1 0 decap_w0
xfeed_1017 1 0 decap_w0
xfeed_1018 1 0 decap_w0
xfeed_1019 1 0 decap_w0
xfeed_22378 1 0 decap_w0
xfeed_22377 1 0 decap_w0
xfeed_22376 1 0 decap_w0
xfeed_22375 1 0 decap_w0
xfeed_22374 1 0 decap_w0
xfeed_22373 1 0 decap_w0
xfeed_22372 1 0 decap_w0
xfeed_22371 1 0 decap_w0
xfeed_22370 1 0 decap_w0
xfeed_9639 1 0 decap_w0
xfeed_9638 1 0 decap_w0
xfeed_9637 1 0 decap_w0
xfeed_9636 1 0 decap_w0
xfeed_9635 1 0 decap_w0
xfeed_9634 1 0 decap_w0
xfeed_9633 1 0 decap_w0
xfeed_9632 1 0 decap_w0
xfeed_9631 1 0 decap_w0
xfeed_9630 1 0 decap_w0
xfeed_5329 1 0 decap_w0
xfeed_5328 1 0 decap_w0
xfeed_5327 1 0 decap_w0
xfeed_5326 1 0 decap_w0
xfeed_5325 1 0 decap_w0
xfeed_5324 1 0 decap_w0
xfeed_5323 1 0 decap_w0
xfeed_26689 1 0 decap_w0
xfeed_26688 1 0 decap_w0
xfeed_26687 1 0 decap_w0
xfeed_26686 1 0 decap_w0
xfeed_26685 1 0 decap_w0
xfeed_26684 1 0 decap_w0
xfeed_26683 1 0 decap_w0
xfeed_26682 1 0 decap_w0
xfeed_26681 1 0 decap_w0
xfeed_26680 1 0 decap_w0
xfeed_22379 1 0 decap_w0
xfeed_21849 1 0 decap_w0
xfeed_21848 1 0 decap_w0
xfeed_21847 1 0 decap_w0
xfeed_21846 1 0 decap_w0
xfeed_21845 1 0 decap_w0
xfeed_21844 1 0 decap_w0
xfeed_21843 1 0 decap_w0
xfeed_21842 1 0 decap_w0
xfeed_21841 1 0 decap_w0
xfeed_21840 1 0 decap_w0
xfeed_16379 1 0 decap_w0
xfeed_16378 1 0 decap_w0
xfeed_16377 1 0 decap_w0
xfeed_16376 1 0 decap_w0
xfeed_16375 1 0 decap_w0
xfeed_16374 1 0 decap_w0
xfeed_16373 1 0 decap_w0
xfeed_16372 1 0 decap_w0
xfeed_16371 1 0 decap_w0
xfeed_16370 1 0 decap_w0
xfeed_15849 1 0 decap_w0
xfeed_15848 1 0 decap_w0
xfeed_15847 1 0 decap_w0
xfeed_15846 1 0 decap_w0
xfeed_15845 1 0 decap_w0
xfeed_15844 1 0 decap_w0
xfeed_15843 1 0 decap_w0
xfeed_15842 1 0 decap_w0
xfeed_15841 1 0 decap_w0
xfeed_15840 1 0 decap_w0
xfeed_12069 1 0 decap_w0
xfeed_12068 1 0 decap_w0
xfeed_12067 1 0 decap_w0
xfeed_12066 1 0 decap_w0
xfeed_12065 1 0 decap_w0
xfeed_12064 1 0 decap_w0
xfeed_12063 1 0 decap_w0
xfeed_12062 1 0 decap_w0
xfeed_12061 1 0 decap_w0
xfeed_12060 1 0 tie
xfeed_11539 1 0 decap_w0
xfeed_11538 1 0 decap_w0
xfeed_11537 1 0 decap_w0
xfeed_11536 1 0 decap_w0
xfeed_11535 1 0 decap_w0
xfeed_11534 1 0 decap_w0
xfeed_11533 1 0 decap_w0
xfeed_11532 1 0 decap_w0
xfeed_11531 1 0 decap_w0
xfeed_11530 1 0 decap_w0
xfeed_1020 1 0 decap_w0
xfeed_1021 1 0 decap_w0
xfeed_1022 1 0 decap_w0
xfeed_1023 1 0 decap_w0
xfeed_1024 1 0 decap_w0
xfeed_1025 1 0 decap_w0
xfeed_1026 1 0 decap_w0
xfeed_1027 1 0 decap_w0
xfeed_1028 1 0 decap_w0
xfeed_1029 1 0 decap_w0
xfeed_27309 1 0 decap_w0
xfeed_27308 1 0 decap_w0
xfeed_27307 1 0 decap_w0
xfeed_27306 1 0 decap_w0
xfeed_27305 1 0 decap_w0
xfeed_27304 1 0 decap_w0
xfeed_27303 1 0 decap_w0
xfeed_27302 1 0 decap_w0
xfeed_27301 1 0 decap_w0
xfeed_27300 1 0 decap_w0
xfeed_22385 1 0 decap_w0
xfeed_22384 1 0 decap_w0
xfeed_22383 1 0 decap_w0
xfeed_22382 1 0 decap_w0
xfeed_22381 1 0 decap_w0
xfeed_22380 1 0 decap_w0
xfeed_9649 1 0 decap_w0
xfeed_9648 1 0 decap_w0
xfeed_9647 1 0 decap_w0
xfeed_9646 1 0 decap_w0
xfeed_9645 1 0 decap_w0
xfeed_9644 1 0 decap_w0
xfeed_9643 1 0 decap_w0
xfeed_9642 1 0 decap_w0
xfeed_9641 1 0 decap_w0
xfeed_9640 1 0 decap_w0
xfeed_5339 1 0 decap_w0
xfeed_5338 1 0 decap_w0
xfeed_5337 1 0 decap_w0
xfeed_5336 1 0 decap_w0
xfeed_5335 1 0 decap_w0
xfeed_5334 1 0 decap_w0
xfeed_5333 1 0 decap_w0
xfeed_5332 1 0 decap_w0
xfeed_5331 1 0 decap_w0
xfeed_5330 1 0 decap_w0
xfeed_4809 1 0 decap_w0
xfeed_4808 1 0 decap_w0
xfeed_4807 1 0 decap_w0
xfeed_4806 1 0 decap_w0
xfeed_4805 1 0 decap_w0
xfeed_4804 1 0 decap_w0
xfeed_4803 1 0 decap_w0
xfeed_4802 1 0 decap_w0
xfeed_4801 1 0 decap_w0
xfeed_4800 1 0 decap_w0
xfeed_26699 1 0 decap_w0
xfeed_26698 1 0 decap_w0
xfeed_26697 1 0 decap_w0
xfeed_26696 1 0 decap_w0
xfeed_26695 1 0 decap_w0
xfeed_26694 1 0 decap_w0
xfeed_26693 1 0 decap_w0
xfeed_26692 1 0 decap_w0
xfeed_26691 1 0 decap_w0
xfeed_26690 1 0 decap_w0
xfeed_22389 1 0 decap_w0
xfeed_22388 1 0 decap_w0
xfeed_22387 1 0 decap_w0
xfeed_22386 1 0 decap_w0
xfeed_21859 1 0 decap_w0
xfeed_21858 1 0 decap_w0
xfeed_21857 1 0 decap_w0
xfeed_21856 1 0 decap_w0
xfeed_21855 1 0 decap_w0
xfeed_21854 1 0 decap_w0
xfeed_21853 1 0 decap_w0
xfeed_21852 1 0 decap_w0
xfeed_21851 1 0 decap_w0
xfeed_21850 1 0 decap_w0
xfeed_16389 1 0 decap_w0
xfeed_16388 1 0 decap_w0
xfeed_16387 1 0 decap_w0
xfeed_16386 1 0 decap_w0
xfeed_16385 1 0 decap_w0
xfeed_16384 1 0 decap_w0
xfeed_16383 1 0 decap_w0
xfeed_16382 1 0 decap_w0
xfeed_16381 1 0 decap_w0
xfeed_16380 1 0 decap_w0
xfeed_15859 1 0 decap_w0
xfeed_15858 1 0 decap_w0
xfeed_15857 1 0 decap_w0
xfeed_15856 1 0 decap_w0
xfeed_15855 1 0 decap_w0
xfeed_15854 1 0 decap_w0
xfeed_15853 1 0 decap_w0
xfeed_15852 1 0 decap_w0
xfeed_15851 1 0 decap_w0
xfeed_15850 1 0 decap_w0
xfeed_12079 1 0 decap_w0
xfeed_12078 1 0 decap_w0
xfeed_12077 1 0 decap_w0
xfeed_12076 1 0 decap_w0
xfeed_12075 1 0 decap_w0
xfeed_12074 1 0 decap_w0
xfeed_12073 1 0 decap_w0
xfeed_12072 1 0 decap_w0
xfeed_12071 1 0 decap_w0
xfeed_12070 1 0 decap_w0
xfeed_11549 1 0 decap_w0
xfeed_11548 1 0 decap_w0
xfeed_11547 1 0 decap_w0
xfeed_11546 1 0 decap_w0
xfeed_11545 1 0 decap_w0
xfeed_11544 1 0 decap_w0
xfeed_11543 1 0 decap_w0
xfeed_11542 1 0 decap_w0
xfeed_11541 1 0 decap_w0
xfeed_11540 1 0 decap_w0
xfeed_1030 1 0 decap_w0
xfeed_1031 1 0 decap_w0
xfeed_1032 1 0 decap_w0
xfeed_1033 1 0 decap_w0
xfeed_1034 1 0 decap_w0
xfeed_1035 1 0 decap_w0
xfeed_1036 1 0 decap_w0
xfeed_27319 1 0 decap_w0
xfeed_27318 1 0 decap_w0
xfeed_27317 1 0 decap_w0
xfeed_27316 1 0 decap_w0
xfeed_27315 1 0 decap_w0
xfeed_27314 1 0 decap_w0
xfeed_27313 1 0 decap_w0
xfeed_27312 1 0 decap_w0
xfeed_27311 1 0 decap_w0
xfeed_27310 1 0 decap_w0
xfeed_23009 1 0 decap_w0
xfeed_23008 1 0 decap_w0
xfeed_23007 1 0 decap_w0
xfeed_23006 1 0 decap_w0
xfeed_23005 1 0 decap_w0
xfeed_23004 1 0 decap_w0
xfeed_23003 1 0 decap_w0
xfeed_23002 1 0 decap_w0
xfeed_23001 1 0 decap_w0
xfeed_23000 1 0 decap_w0
xfeed_22392 1 0 decap_w0
xfeed_22391 1 0 decap_w0
xfeed_22390 1 0 decap_w0
xfeed_17002 1 0 decap_w0
xfeed_17001 1 0 decap_w0
xfeed_17000 1 0 decap_w0
xfeed_9659 1 0 decap_w0
xfeed_9658 1 0 decap_w0
xfeed_9657 1 0 decap_w0
xfeed_9656 1 0 decap_w0
xfeed_9655 1 0 decap_w0
xfeed_9654 1 0 decap_w0
xfeed_9653 1 0 decap_w0
xfeed_9652 1 0 decap_w0
xfeed_9651 1 0 decap_w0
xfeed_9650 1 0 decap_w0
xfeed_5349 1 0 decap_w0
xfeed_5348 1 0 decap_w0
xfeed_5347 1 0 decap_w0
xfeed_5346 1 0 decap_w0
xfeed_5345 1 0 decap_w0
xfeed_5344 1 0 decap_w0
xfeed_5343 1 0 decap_w0
xfeed_5342 1 0 decap_w0
xfeed_5341 1 0 decap_w0
xfeed_5340 1 0 decap_w0
xfeed_4819 1 0 decap_w0
xfeed_4818 1 0 decap_w0
xfeed_4817 1 0 decap_w0
xfeed_4816 1 0 decap_w0
xfeed_4815 1 0 decap_w0
xfeed_4814 1 0 decap_w0
xfeed_4813 1 0 decap_w0
xfeed_4812 1 0 decap_w0
xfeed_4811 1 0 decap_w0
xfeed_4810 1 0 decap_w0
xsubckt_55_xor2_x0 1 0 63 33 172 xor2_x0
xfeed_1037 1 0 decap_w0
xfeed_1038 1 0 decap_w0
xfeed_1039 1 0 decap_w0
xfeed_22399 1 0 decap_w0
xfeed_22398 1 0 decap_w0
xfeed_22397 1 0 decap_w0
xfeed_22396 1 0 decap_w0
xfeed_22395 1 0 decap_w0
xfeed_22394 1 0 decap_w0
xfeed_22393 1 0 decap_w0
xfeed_21869 1 0 decap_w0
xfeed_21868 1 0 decap_w0
xfeed_21867 1 0 decap_w0
xfeed_21866 1 0 decap_w0
xfeed_21865 1 0 decap_w0
xfeed_21864 1 0 decap_w0
xfeed_21863 1 0 decap_w0
xfeed_21862 1 0 decap_w0
xfeed_21861 1 0 decap_w0
xfeed_21860 1 0 decap_w0
xfeed_17009 1 0 decap_w0
xfeed_17008 1 0 decap_w0
xfeed_17007 1 0 decap_w0
xfeed_17006 1 0 decap_w0
xfeed_17005 1 0 decap_w0
xfeed_17004 1 0 decap_w0
xfeed_17003 1 0 decap_w0
xfeed_16399 1 0 decap_w0
xfeed_16398 1 0 decap_w0
xfeed_16397 1 0 decap_w0
xfeed_16396 1 0 decap_w0
xfeed_16395 1 0 decap_w0
xfeed_16394 1 0 decap_w0
xfeed_16393 1 0 decap_w0
xfeed_16392 1 0 decap_w0
xfeed_16391 1 0 decap_w0
xfeed_16390 1 0 decap_w0
xfeed_15869 1 0 decap_w0
xfeed_15868 1 0 decap_w0
xfeed_15867 1 0 decap_w0
xfeed_15866 1 0 decap_w0
xfeed_15865 1 0 decap_w0
xfeed_15864 1 0 decap_w0
xfeed_15863 1 0 decap_w0
xfeed_15862 1 0 decap_w0
xfeed_15861 1 0 decap_w0
xfeed_15860 1 0 decap_w0
xfeed_12089 1 0 decap_w0
xfeed_12088 1 0 decap_w0
xfeed_12087 1 0 decap_w0
xfeed_12086 1 0 decap_w0
xfeed_12085 1 0 decap_w0
xfeed_12084 1 0 decap_w0
xfeed_12083 1 0 decap_w0
xfeed_12082 1 0 decap_w0
xfeed_12081 1 0 decap_w0
xfeed_12080 1 0 decap_w0
xfeed_11559 1 0 decap_w0
xfeed_11558 1 0 decap_w0
xfeed_11557 1 0 decap_w0
xfeed_11556 1 0 decap_w0
xfeed_11555 1 0 decap_w0
xfeed_11554 1 0 decap_w0
xfeed_11553 1 0 decap_w0
xfeed_11552 1 0 decap_w0
xfeed_11551 1 0 decap_w0
xfeed_11550 1 0 decap_w0
xfeed_1040 1 0 decap_w0
xfeed_1041 1 0 decap_w0
xfeed_1042 1 0 decap_w0
xfeed_1043 1 0 decap_w0
xfeed_27329 1 0 decap_w0
xfeed_27328 1 0 decap_w0
xfeed_27327 1 0 decap_w0
xfeed_27326 1 0 decap_w0
xfeed_27325 1 0 decap_w0
xfeed_27324 1 0 decap_w0
xfeed_27323 1 0 decap_w0
xfeed_27322 1 0 decap_w0
xfeed_27321 1 0 decap_w0
xfeed_27320 1 0 decap_w0
xfeed_23019 1 0 decap_w0
xfeed_23018 1 0 decap_w0
xfeed_23017 1 0 decap_w0
xfeed_23016 1 0 decap_w0
xfeed_23015 1 0 decap_w0
xfeed_23014 1 0 decap_w0
xfeed_23013 1 0 decap_w0
xfeed_23012 1 0 decap_w0
xfeed_23011 1 0 decap_w0
xfeed_23010 1 0 decap_w0
xfeed_9669 1 0 decap_w0
xfeed_9668 1 0 decap_w0
xfeed_9667 1 0 decap_w0
xfeed_9666 1 0 decap_w0
xfeed_9665 1 0 decap_w0
xfeed_9664 1 0 decap_w0
xfeed_9663 1 0 decap_w0
xfeed_9662 1 0 decap_w0
xfeed_9661 1 0 decap_w0
xfeed_9660 1 0 decap_w0
xfeed_5359 1 0 decap_w0
xfeed_5358 1 0 decap_w0
xfeed_5357 1 0 decap_w0
xfeed_5356 1 0 decap_w0
xfeed_5355 1 0 decap_w0
xfeed_5354 1 0 decap_w0
xfeed_5353 1 0 decap_w0
xfeed_5352 1 0 decap_w0
xfeed_5351 1 0 decap_w0
xfeed_5350 1 0 decap_w0
xfeed_4829 1 0 decap_w0
xfeed_4828 1 0 decap_w0
xfeed_4827 1 0 decap_w0
xfeed_4826 1 0 decap_w0
xfeed_4825 1 0 tie
xfeed_4824 1 0 decap_w0
xfeed_4823 1 0 decap_w0
xfeed_4822 1 0 decap_w0
xfeed_4821 1 0 decap_w0
xfeed_4820 1 0 decap_w0
xfeed_1044 1 0 decap_w0
xfeed_1045 1 0 decap_w0
xfeed_1046 1 0 decap_w0
xfeed_1047 1 0 decap_w0
xfeed_1048 1 0 decap_w0
xfeed_1049 1 0 decap_w0
xfeed_21879 1 0 decap_w0
xfeed_21878 1 0 decap_w0
xfeed_21877 1 0 decap_w0
xfeed_21876 1 0 decap_w0
xfeed_21875 1 0 decap_w0
xfeed_21874 1 0 decap_w0
xfeed_21873 1 0 decap_w0
xfeed_21872 1 0 decap_w0
xfeed_21871 1 0 decap_w0
xfeed_21870 1 0 decap_w0
xfeed_17019 1 0 decap_w0
xfeed_17018 1 0 decap_w0
xfeed_17017 1 0 decap_w0
xfeed_17016 1 0 decap_w0
xfeed_17015 1 0 decap_w0
xfeed_17014 1 0 decap_w0
xfeed_17013 1 0 decap_w0
xfeed_17012 1 0 decap_w0
xfeed_17011 1 0 decap_w0
xfeed_17010 1 0 decap_w0
xfeed_15879 1 0 decap_w0
xfeed_15878 1 0 decap_w0
xfeed_15877 1 0 decap_w0
xfeed_15876 1 0 decap_w0
xfeed_15875 1 0 decap_w0
xfeed_15874 1 0 decap_w0
xfeed_15873 1 0 decap_w0
xfeed_15872 1 0 decap_w0
xfeed_15871 1 0 decap_w0
xfeed_15870 1 0 decap_w0
xfeed_12099 1 0 decap_w0
xfeed_12098 1 0 decap_w0
xfeed_12097 1 0 decap_w0
xfeed_12096 1 0 decap_w0
xfeed_12095 1 0 decap_w0
xfeed_12094 1 0 decap_w0
xfeed_12093 1 0 decap_w0
xfeed_12092 1 0 decap_w0
xfeed_12091 1 0 decap_w0
xfeed_12090 1 0 decap_w0
xfeed_11569 1 0 decap_w0
xfeed_11568 1 0 decap_w0
xfeed_11567 1 0 decap_w0
xfeed_11566 1 0 decap_w0
xfeed_11565 1 0 decap_w0
xfeed_11564 1 0 decap_w0
xfeed_11563 1 0 decap_w0
xfeed_11562 1 0 decap_w0
xfeed_11561 1 0 decap_w0
xfeed_11560 1 0 decap_w0
xfeed_1050 1 0 decap_w0
xfeed_27339 1 0 decap_w0
xfeed_27338 1 0 decap_w0
xfeed_27337 1 0 decap_w0
xfeed_27336 1 0 decap_w0
xfeed_27335 1 0 decap_w0
xfeed_27334 1 0 decap_w0
xfeed_27333 1 0 decap_w0
xfeed_27332 1 0 decap_w0
xfeed_27331 1 0 decap_w0
xfeed_27330 1 0 decap_w0
xfeed_26804 1 0 decap_w0
xfeed_26803 1 0 decap_w0
xfeed_26802 1 0 decap_w0
xfeed_26801 1 0 decap_w0
xfeed_26800 1 0 decap_w0
xfeed_23029 1 0 decap_w0
xfeed_23028 1 0 decap_w0
xfeed_23027 1 0 decap_w0
xfeed_23026 1 0 decap_w0
xfeed_23025 1 0 decap_w0
xfeed_23024 1 0 decap_w0
xfeed_23023 1 0 decap_w0
xfeed_23022 1 0 decap_w0
xfeed_23021 1 0 decap_w0
xfeed_23020 1 0 decap_w0
xfeed_9679 1 0 decap_w0
xfeed_9678 1 0 decap_w0
xfeed_9677 1 0 decap_w0
xfeed_9676 1 0 tie
xfeed_9675 1 0 decap_w0
xfeed_9674 1 0 decap_w0
xfeed_9673 1 0 decap_w0
xfeed_9672 1 0 decap_w0
xfeed_9671 1 0 decap_w0
xfeed_9670 1 0 decap_w0
xfeed_5369 1 0 decap_w0
xfeed_5368 1 0 decap_w0
xfeed_5367 1 0 decap_w0
xfeed_5366 1 0 decap_w0
xfeed_5365 1 0 decap_w0
xfeed_5364 1 0 decap_w0
xfeed_5363 1 0 decap_w0
xfeed_5362 1 0 decap_w0
xfeed_5361 1 0 decap_w0
xfeed_5360 1 0 decap_w0
xfeed_4839 1 0 decap_w0
xfeed_4838 1 0 decap_w0
xfeed_4837 1 0 decap_w0
xfeed_4836 1 0 decap_w0
xfeed_4835 1 0 decap_w0
xfeed_4834 1 0 decap_w0
xfeed_4833 1 0 decap_w0
xfeed_4832 1 0 decap_w0
xfeed_4831 1 0 decap_w0
xfeed_4830 1 0 decap_w0
xfeed_1051 1 0 decap_w0
xfeed_1052 1 0 decap_w0
xfeed_1053 1 0 decap_w0
xfeed_1054 1 0 decap_w0
xfeed_1055 1 0 decap_w0
xfeed_1056 1 0 decap_w0
xfeed_1057 1 0 decap_w0
xfeed_1058 1 0 decap_w0
xfeed_1059 1 0 decap_w0
xfeed_26809 1 0 decap_w0
xfeed_26808 1 0 decap_w0
xfeed_26807 1 0 decap_w0
xfeed_26806 1 0 decap_w0
xfeed_26805 1 0 decap_w0
xfeed_21889 1 0 decap_w0
xfeed_21888 1 0 decap_w0
xfeed_21887 1 0 decap_w0
xfeed_21886 1 0 decap_w0
xfeed_21885 1 0 decap_w0
xfeed_21884 1 0 decap_w0
xfeed_21883 1 0 decap_w0
xfeed_21882 1 0 decap_w0
xfeed_21881 1 0 decap_w0
xfeed_21880 1 0 decap_w0
xfeed_17029 1 0 decap_w0
xfeed_17028 1 0 decap_w0
xfeed_17027 1 0 decap_w0
xfeed_17026 1 0 decap_w0
xfeed_17025 1 0 decap_w0
xfeed_17024 1 0 decap_w0
xfeed_17023 1 0 decap_w0
xfeed_17022 1 0 decap_w0
xfeed_17021 1 0 decap_w0
xfeed_17020 1 0 decap_w0
xfeed_15889 1 0 decap_w0
xfeed_15888 1 0 decap_w0
xfeed_15887 1 0 decap_w0
xfeed_15886 1 0 decap_w0
xfeed_15885 1 0 decap_w0
xfeed_15884 1 0 decap_w0
xfeed_15883 1 0 decap_w0
xfeed_15882 1 0 decap_w0
xfeed_15881 1 0 decap_w0
xfeed_15880 1 0 decap_w0
xfeed_11579 1 0 decap_w0
xfeed_11578 1 0 decap_w0
xfeed_11577 1 0 decap_w0
xfeed_11576 1 0 decap_w0
xfeed_11575 1 0 decap_w0
xfeed_11574 1 0 decap_w0
xfeed_11573 1 0 decap_w0
xfeed_11572 1 0 decap_w0
xfeed_11571 1 0 decap_w0
xfeed_11570 1 0 decap_w0
xfeed_27349 1 0 decap_w0
xfeed_27348 1 0 decap_w0
xfeed_27347 1 0 decap_w0
xfeed_27346 1 0 decap_w0
xfeed_27345 1 0 decap_w0
xfeed_27344 1 0 decap_w0
xfeed_27343 1 0 decap_w0
xfeed_27342 1 0 decap_w0
xfeed_27341 1 0 decap_w0
xfeed_27340 1 0 decap_w0
xfeed_26811 1 0 decap_w0
xfeed_26810 1 0 decap_w0
xfeed_23039 1 0 decap_w0
xfeed_23038 1 0 decap_w0
xfeed_23037 1 0 decap_w0
xfeed_23036 1 0 decap_w0
xfeed_23035 1 0 decap_w0
xfeed_23034 1 0 decap_w0
xfeed_23033 1 0 decap_w0
xfeed_23032 1 0 decap_w0
xfeed_23031 1 0 decap_w0
xfeed_23030 1 0 decap_w0
xfeed_22509 1 0 decap_w0
xfeed_22508 1 0 decap_w0
xfeed_22507 1 0 decap_w0
xfeed_22506 1 0 decap_w0
xfeed_22505 1 0 decap_w0
xfeed_22504 1 0 decap_w0
xfeed_22503 1 0 decap_w0
xfeed_22502 1 0 decap_w0
xfeed_22501 1 0 decap_w0
xfeed_22500 1 0 decap_w0
xfeed_9689 1 0 decap_w0
xfeed_9688 1 0 decap_w0
xfeed_9687 1 0 decap_w0
xfeed_9686 1 0 decap_w0
xfeed_9685 1 0 decap_w0
xfeed_9684 1 0 decap_w0
xfeed_9683 1 0 decap_w0
xfeed_9682 1 0 decap_w0
xfeed_9681 1 0 decap_w0
xfeed_9680 1 0 decap_w0
xfeed_5379 1 0 decap_w0
xfeed_5378 1 0 decap_w0
xfeed_5377 1 0 decap_w0
xfeed_5376 1 0 decap_w0
xfeed_5375 1 0 decap_w0
xfeed_5374 1 0 decap_w0
xfeed_5373 1 0 decap_w0
xfeed_5372 1 0 decap_w0
xfeed_5371 1 0 decap_w0
xfeed_5370 1 0 decap_w0
xfeed_4849 1 0 decap_w0
xfeed_4848 1 0 decap_w0
xfeed_4847 1 0 decap_w0
xfeed_4846 1 0 decap_w0
xfeed_4845 1 0 decap_w0
xfeed_4844 1 0 decap_w0
xfeed_4843 1 0 decap_w0
xfeed_4842 1 0 decap_w0
xfeed_4841 1 0 decap_w0
xfeed_4840 1 0 decap_w0
xfeed_1060 1 0 decap_w0
xfeed_1061 1 0 decap_w0
xfeed_1062 1 0 decap_w0
xfeed_1063 1 0 decap_w0
xfeed_1064 1 0 decap_w0
xfeed_1065 1 0 decap_w0
xfeed_1066 1 0 decap_w0
xfeed_1067 1 0 decap_w0
xfeed_1068 1 0 decap_w0
xfeed_1069 1 0 decap_w0
xfeed_26819 1 0 decap_w0
xfeed_26818 1 0 decap_w0
xfeed_26817 1 0 decap_w0
xfeed_26816 1 0 decap_w0
xfeed_26815 1 0 decap_w0
xfeed_26814 1 0 decap_w0
xfeed_26813 1 0 decap_w0
xfeed_26812 1 0 decap_w0
xfeed_21899 1 0 decap_w0
xfeed_21898 1 0 decap_w0
xfeed_21897 1 0 decap_w0
xfeed_21896 1 0 decap_w0
xfeed_21895 1 0 decap_w0
xfeed_21894 1 0 decap_w0
xfeed_21893 1 0 decap_w0
xfeed_21892 1 0 decap_w0
xfeed_21891 1 0 decap_w0
xfeed_21890 1 0 decap_w0
xfeed_17039 1 0 decap_w0
xfeed_17038 1 0 decap_w0
xfeed_17037 1 0 decap_w0
xfeed_17036 1 0 decap_w0
xfeed_17035 1 0 decap_w0
xfeed_17034 1 0 decap_w0
xfeed_17033 1 0 decap_w0
xfeed_17032 1 0 decap_w0
xfeed_17031 1 0 decap_w0
xfeed_17030 1 0 decap_w0
xfeed_16509 1 0 decap_w0
xfeed_16508 1 0 decap_w0
xfeed_16507 1 0 decap_w0
xfeed_16506 1 0 decap_w0
xfeed_16505 1 0 decap_w0
xfeed_16504 1 0 decap_w0
xfeed_16503 1 0 decap_w0
xfeed_16502 1 0 decap_w0
xfeed_16501 1 0 decap_w0
xfeed_16500 1 0 decap_w0
xfeed_15899 1 0 decap_w0
xfeed_15898 1 0 decap_w0
xfeed_15897 1 0 decap_w0
xfeed_15896 1 0 decap_w0
xfeed_15895 1 0 decap_w0
xfeed_15894 1 0 decap_w0
xfeed_15893 1 0 decap_w0
xfeed_15892 1 0 decap_w0
xfeed_15891 1 0 decap_w0
xfeed_15890 1 0 decap_w0
xfeed_11589 1 0 decap_w0
xfeed_11588 1 0 decap_w0
xfeed_11587 1 0 decap_w0
xfeed_11586 1 0 decap_w0
xfeed_11585 1 0 decap_w0
xfeed_11584 1 0 decap_w0
xfeed_11583 1 0 decap_w0
xfeed_11582 1 0 decap_w0
xfeed_11581 1 0 decap_w0
xfeed_11580 1 0 decap_w0
xfeed_27357 1 0 decap_w0
xfeed_27356 1 0 decap_w0
xfeed_27355 1 0 decap_w0
xfeed_27354 1 0 decap_w0
xfeed_27353 1 0 decap_w0
xfeed_27352 1 0 decap_w0
xfeed_27351 1 0 decap_w0
xfeed_27350 1 0 decap_w0
xfeed_23049 1 0 decap_w0
xfeed_23048 1 0 decap_w0
xfeed_23047 1 0 decap_w0
xfeed_23046 1 0 decap_w0
xfeed_23045 1 0 decap_w0
xfeed_23044 1 0 decap_w0
xfeed_23043 1 0 decap_w0
xfeed_23042 1 0 decap_w0
xfeed_23041 1 0 decap_w0
xfeed_23040 1 0 decap_w0
xfeed_22518 1 0 decap_w0
xfeed_22517 1 0 decap_w0
xfeed_22516 1 0 decap_w0
xfeed_22515 1 0 decap_w0
xfeed_22514 1 0 decap_w0
xfeed_22513 1 0 decap_w0
xfeed_22512 1 0 decap_w0
xfeed_22511 1 0 decap_w0
xfeed_22510 1 0 decap_w0
xfeed_9699 1 0 decap_w0
xfeed_9698 1 0 decap_w0
xfeed_9697 1 0 decap_w0
xfeed_9696 1 0 decap_w0
xfeed_9695 1 0 decap_w0
xfeed_9694 1 0 decap_w0
xfeed_9693 1 0 decap_w0
xfeed_9692 1 0 decap_w0
xfeed_9691 1 0 decap_w0
xfeed_9690 1 0 decap_w0
xfeed_5389 1 0 decap_w0
xfeed_5388 1 0 decap_w0
xfeed_5387 1 0 decap_w0
xfeed_5386 1 0 decap_w0
xfeed_5385 1 0 decap_w0
xfeed_5384 1 0 decap_w0
xfeed_5383 1 0 decap_w0
xfeed_5382 1 0 decap_w0
xfeed_5381 1 0 decap_w0
xfeed_5380 1 0 decap_w0
xfeed_4859 1 0 decap_w0
xfeed_4858 1 0 decap_w0
xfeed_4857 1 0 decap_w0
xfeed_4856 1 0 decap_w0
xfeed_4855 1 0 decap_w0
xfeed_4854 1 0 decap_w0
xfeed_4853 1 0 decap_w0
xfeed_4852 1 0 decap_w0
xfeed_4851 1 0 decap_w0
xfeed_4850 1 0 decap_w0
xfeed_1070 1 0 decap_w0
xfeed_1071 1 0 decap_w0
xfeed_1072 1 0 decap_w0
xfeed_1073 1 0 decap_w0
xfeed_1074 1 0 decap_w0
xfeed_1075 1 0 decap_w0
xfeed_1076 1 0 decap_w0
xfeed_1077 1 0 decap_w0
xfeed_1078 1 0 decap_w0
xfeed_1079 1 0 decap_w0
xfeed_27359 1 0 decap_w0
xfeed_27358 1 0 decap_w0
xfeed_26829 1 0 decap_w0
xfeed_26828 1 0 decap_w0
xfeed_26827 1 0 decap_w0
xfeed_26826 1 0 decap_w0
xfeed_26825 1 0 decap_w0
xfeed_26824 1 0 decap_w0
xfeed_26823 1 0 decap_w0
xfeed_26822 1 0 decap_w0
xfeed_26821 1 0 decap_w0
xfeed_26820 1 0 decap_w0
xfeed_22519 1 0 decap_w0
xfeed_17049 1 0 decap_w0
xfeed_17048 1 0 decap_w0
xfeed_17047 1 0 decap_w0
xfeed_17046 1 0 decap_w0
xfeed_17045 1 0 decap_w0
xfeed_17044 1 0 decap_w0
xfeed_17043 1 0 decap_w0
xfeed_17042 1 0 decap_w0
xfeed_17041 1 0 decap_w0
xfeed_17040 1 0 decap_w0
xfeed_16519 1 0 decap_w0
xfeed_16518 1 0 decap_w0
xfeed_16517 1 0 decap_w0
xfeed_16516 1 0 decap_w0
xfeed_16515 1 0 decap_w0
xfeed_16514 1 0 decap_w0
xfeed_16513 1 0 decap_w0
xfeed_16512 1 0 decap_w0
xfeed_16511 1 0 decap_w0
xfeed_16510 1 0 decap_w0
xfeed_12209 1 0 decap_w0
xfeed_12208 1 0 decap_w0
xfeed_12207 1 0 decap_w0
xfeed_12206 1 0 decap_w0
xfeed_12205 1 0 decap_w0
xfeed_12204 1 0 decap_w0
xfeed_12203 1 0 decap_w0
xfeed_12202 1 0 decap_w0
xfeed_12201 1 0 decap_w0
xfeed_12200 1 0 decap_w0
xfeed_11599 1 0 decap_w0
xfeed_11598 1 0 decap_w0
xfeed_11597 1 0 decap_w0
xfeed_11596 1 0 decap_w0
xfeed_11595 1 0 decap_w0
xfeed_11594 1 0 decap_w0
xfeed_11593 1 0 decap_w0
xfeed_11592 1 0 decap_w0
xfeed_11591 1 0 decap_w0
xfeed_11590 1 0 decap_w0
xfeed_6008 1 0 decap_w0
xfeed_6007 1 0 decap_w0
xfeed_6006 1 0 decap_w0
xfeed_6005 1 0 decap_w0
xfeed_6004 1 0 decap_w0
xfeed_6003 1 0 decap_w0
xfeed_6002 1 0 decap_w0
xfeed_6001 1 0 decap_w0
xfeed_6000 1 0 decap_w0
xfeed_27364 1 0 decap_w0
xfeed_27363 1 0 decap_w0
xfeed_27362 1 0 decap_w0
xfeed_27361 1 0 decap_w0
xfeed_27360 1 0 decap_w0
xfeed_23059 1 0 decap_w0
xfeed_23058 1 0 decap_w0
xfeed_23057 1 0 decap_w0
xfeed_23056 1 0 decap_w0
xfeed_23055 1 0 decap_w0
xfeed_23054 1 0 decap_w0
xfeed_23053 1 0 decap_w0
xfeed_23052 1 0 decap_w0
xfeed_23051 1 0 decap_w0
xfeed_23050 1 0 decap_w0
xfeed_22525 1 0 decap_w0
xfeed_22524 1 0 decap_w0
xfeed_22523 1 0 decap_w0
xfeed_22522 1 0 decap_w0
xfeed_22521 1 0 decap_w0
xfeed_22520 1 0 decap_w0
xfeed_6009 1 0 decap_w0
xfeed_5399 1 0 decap_w0
xfeed_5398 1 0 decap_w0
xfeed_5397 1 0 decap_w0
xfeed_5396 1 0 decap_w0
xfeed_5395 1 0 decap_w0
xfeed_5394 1 0 decap_w0
xfeed_5393 1 0 decap_w0
xfeed_5392 1 0 decap_w0
xfeed_5391 1 0 decap_w0
xfeed_5390 1 0 decap_w0
xfeed_4869 1 0 decap_w0
xfeed_4868 1 0 decap_w0
xfeed_4867 1 0 decap_w0
xfeed_4866 1 0 decap_w0
xfeed_4865 1 0 decap_w0
xfeed_4864 1 0 decap_w0
xfeed_4863 1 0 decap_w0
xfeed_4862 1 0 decap_w0
xfeed_4861 1 0 decap_w0
xfeed_4860 1 0 decap_w0
xfeed_1080 1 0 decap_w0
xfeed_1081 1 0 decap_w0
xfeed_1082 1 0 decap_w0
xfeed_1083 1 0 decap_w0
xfeed_1084 1 0 decap_w0
xfeed_1085 1 0 decap_w0
xfeed_1086 1 0 decap_w0
xfeed_1087 1 0 decap_w0
xfeed_1088 1 0 decap_w0
xfeed_1089 1 0 decap_w0
xfeed_27369 1 0 decap_w0
xfeed_27368 1 0 decap_w0
xfeed_27367 1 0 decap_w0
xfeed_27366 1 0 decap_w0
xfeed_27365 1 0 decap_w0
xfeed_26839 1 0 decap_w0
xfeed_26838 1 0 decap_w0
xfeed_26837 1 0 decap_w0
xfeed_26836 1 0 decap_w0
xfeed_26835 1 0 decap_w0
xfeed_26834 1 0 decap_w0
xfeed_26833 1 0 decap_w0
xfeed_26832 1 0 decap_w0
xfeed_26831 1 0 decap_w0
xfeed_26830 1 0 decap_w0
xfeed_22529 1 0 decap_w0
xfeed_22528 1 0 decap_w0
xfeed_22527 1 0 decap_w0
xfeed_22526 1 0 decap_w0
xfeed_17059 1 0 decap_w0
xfeed_17058 1 0 decap_w0
xfeed_17057 1 0 decap_w0
xfeed_17056 1 0 decap_w0
xfeed_17055 1 0 decap_w0
xfeed_17054 1 0 decap_w0
xfeed_17053 1 0 decap_w0
xfeed_17051 1 0 decap_w0
xfeed_17050 1 0 decap_w0
xfeed_16529 1 0 decap_w0
xfeed_16528 1 0 decap_w0
xfeed_16527 1 0 decap_w0
xfeed_16526 1 0 decap_w0
xfeed_16525 1 0 decap_w0
xfeed_16524 1 0 decap_w0
xfeed_16523 1 0 decap_w0
xfeed_16522 1 0 decap_w0
xfeed_16521 1 0 decap_w0
xfeed_16520 1 0 decap_w0
xfeed_12219 1 0 decap_w0
xfeed_12218 1 0 decap_w0
xfeed_12217 1 0 decap_w0
xfeed_12216 1 0 decap_w0
xfeed_12215 1 0 decap_w0
xfeed_12214 1 0 decap_w0
xfeed_12213 1 0 decap_w0
xfeed_12212 1 0 decap_w0
xfeed_12211 1 0 decap_w0
xfeed_12210 1 0 decap_w0
xfeed_6015 1 0 decap_w0
xfeed_6014 1 0 decap_w0
xfeed_6013 1 0 decap_w0
xfeed_6012 1 0 decap_w0
xfeed_6011 1 0 decap_w0
xfeed_6010 1 0 decap_w0
xfeed_27371 1 0 decap_w0
xfeed_27370 1 0 decap_w0
xfeed_23069 1 0 decap_w0
xfeed_23068 1 0 decap_w0
xfeed_23067 1 0 decap_w0
xfeed_23066 1 0 decap_w0
xfeed_23065 1 0 decap_w0
xfeed_23064 1 0 decap_w0
xfeed_23063 1 0 decap_w0
xfeed_23062 1 0 decap_w0
xfeed_23061 1 0 decap_w0
xfeed_23060 1 0 decap_w0
xfeed_22532 1 0 decap_w0
xfeed_22531 1 0 decap_w0
xfeed_22530 1 0 decap_w0
xfeed_6019 1 0 decap_w0
xfeed_6018 1 0 decap_w0
xfeed_6017 1 0 decap_w0
xfeed_6016 1 0 decap_w0
xfeed_4879 1 0 decap_w0
xfeed_4878 1 0 decap_w0
xfeed_4877 1 0 decap_w0
xfeed_4876 1 0 decap_w0
xfeed_4875 1 0 decap_w0
xfeed_4874 1 0 decap_w0
xfeed_4873 1 0 decap_w0
xfeed_4872 1 0 decap_w0
xfeed_4871 1 0 decap_w0
xfeed_4870 1 0 decap_w0
xfeed_1090 1 0 decap_w0
xfeed_1091 1 0 decap_w0
xfeed_1092 1 0 decap_w0
xfeed_1093 1 0 decap_w0
xfeed_1094 1 0 decap_w0
xfeed_1095 1 0 decap_w0
xfeed_1096 1 0 decap_w0
xfeed_1097 1 0 decap_w0
xfeed_1098 1 0 decap_w0
xfeed_1099 1 0 decap_w0
xfeed_27379 1 0 decap_w0
xfeed_27378 1 0 decap_w0
xfeed_27377 1 0 decap_w0
xfeed_27376 1 0 decap_w0
xfeed_27375 1 0 decap_w0
xfeed_27374 1 0 decap_w0
xfeed_27373 1 0 decap_w0
xfeed_27372 1 0 decap_w0
xfeed_26849 1 0 decap_w0
xfeed_26848 1 0 decap_w0
xfeed_26847 1 0 decap_w0
xfeed_26846 1 0 decap_w0
xfeed_26845 1 0 decap_w0
xfeed_26844 1 0 decap_w0
xfeed_26843 1 0 decap_w0
xfeed_26842 1 0 decap_w0
xfeed_26841 1 0 decap_w0
xfeed_26840 1 0 decap_w0
xfeed_22539 1 0 decap_w0
xfeed_22538 1 0 decap_w0
xfeed_22537 1 0 decap_w0
xfeed_22536 1 0 decap_w0
xfeed_22535 1 0 decap_w0
xfeed_22534 1 0 decap_w0
xfeed_22533 1 0 decap_w0
xfeed_17069 1 0 decap_w0
xfeed_17068 1 0 decap_w0
xfeed_17067 1 0 decap_w0
xfeed_17066 1 0 decap_w0
xfeed_17065 1 0 decap_w0
xfeed_17064 1 0 decap_w0
xfeed_17063 1 0 decap_w0
xfeed_17062 1 0 decap_w0
xfeed_17061 1 0 decap_w0
xfeed_17060 1 0 decap_w0
xfeed_16539 1 0 decap_w0
xfeed_16538 1 0 decap_w0
xfeed_16537 1 0 decap_w0
xfeed_16536 1 0 decap_w0
xfeed_16535 1 0 decap_w0
xfeed_16534 1 0 decap_w0
xfeed_16533 1 0 decap_w0
xfeed_16532 1 0 decap_w0
xfeed_16531 1 0 decap_w0
xfeed_16530 1 0 decap_w0
xfeed_12229 1 0 decap_w0
xfeed_12228 1 0 decap_w0
xfeed_12227 1 0 decap_w0
xfeed_12226 1 0 decap_w0
xfeed_12225 1 0 decap_w0
xfeed_12224 1 0 decap_w0
xfeed_12223 1 0 decap_w0
xfeed_12222 1 0 decap_w0
xfeed_12221 1 0 decap_w0
xfeed_12220 1 0 decap_w0
xfeed_6022 1 0 decap_w0
xfeed_6021 1 0 decap_w0
xfeed_6020 1 0 decap_w0
xfeed_23078 1 0 decap_w0
xfeed_23077 1 0 decap_w0
xfeed_23076 1 0 decap_w0
xfeed_23075 1 0 decap_w0
xfeed_23074 1 0 decap_w0
xfeed_23073 1 0 decap_w0
xfeed_23072 1 0 decap_w0
xfeed_23071 1 0 decap_w0
xfeed_23070 1 0 decap_w0
xfeed_9809 1 0 decap_w0
xfeed_9808 1 0 decap_w0
xfeed_9807 1 0 decap_w0
xfeed_9806 1 0 decap_w0
xfeed_9805 1 0 decap_w0
xfeed_9804 1 0 decap_w0
xfeed_9803 1 0 decap_w0
xfeed_9802 1 0 decap_w0
xfeed_9801 1 0 decap_w0
xfeed_9800 1 0 decap_w0
xfeed_6029 1 0 decap_w0
xfeed_6028 1 0 decap_w0
xfeed_6027 1 0 decap_w0
xfeed_6026 1 0 decap_w0
xfeed_6025 1 0 decap_w0
xfeed_6024 1 0 decap_w0
xfeed_6023 1 0 decap_w0
xfeed_4889 1 0 decap_w0
xfeed_4888 1 0 decap_w0
xfeed_4887 1 0 decap_w0
xfeed_4886 1 0 decap_w0
xfeed_4885 1 0 decap_w0
xfeed_4884 1 0 decap_w0
xfeed_4883 1 0 decap_w0
xfeed_4882 1 0 decap_w0
xfeed_4881 1 0 decap_w0
xfeed_4880 1 0 decap_w0
xfeed_27389 1 0 decap_w0
xfeed_27388 1 0 decap_w0
xfeed_27387 1 0 decap_w0
xfeed_27386 1 0 decap_w0
xfeed_27385 1 0 decap_w0
xfeed_27384 1 0 decap_w0
xfeed_27383 1 0 decap_w0
xfeed_27382 1 0 decap_w0
xfeed_27381 1 0 decap_w0
xfeed_27380 1 0 decap_w0
xfeed_26859 1 0 decap_w0
xfeed_26858 1 0 decap_w0
xfeed_26857 1 0 decap_w0
xfeed_26856 1 0 decap_w0
xfeed_26855 1 0 decap_w0
xfeed_26854 1 0 decap_w0
xfeed_26853 1 0 decap_w0
xfeed_26852 1 0 decap_w0
xfeed_26851 1 0 decap_w0
xfeed_26850 1 0 decap_w0
xfeed_23079 1 0 decap_w0
xfeed_22549 1 0 decap_w0
xfeed_22548 1 0 decap_w0
xfeed_22547 1 0 decap_w0
xfeed_22546 1 0 decap_w0
xfeed_22545 1 0 decap_w0
xfeed_22544 1 0 decap_w0
xfeed_22543 1 0 decap_w0
xfeed_22542 1 0 decap_w0
xfeed_22541 1 0 decap_w0
xfeed_22540 1 0 decap_w0
xfeed_17079 1 0 decap_w0
xfeed_17078 1 0 decap_w0
xfeed_17077 1 0 decap_w0
xfeed_17076 1 0 decap_w0
xfeed_17075 1 0 decap_w0
xfeed_17074 1 0 decap_w0
xfeed_17073 1 0 decap_w0
xfeed_17072 1 0 decap_w0
xfeed_17071 1 0 decap_w0
xfeed_17070 1 0 decap_w0
xfeed_16549 1 0 decap_w0
xfeed_16548 1 0 decap_w0
xfeed_16547 1 0 decap_w0
xfeed_16546 1 0 decap_w0
xfeed_16545 1 0 decap_w0
xfeed_16544 1 0 decap_w0
xfeed_16543 1 0 decap_w0
xfeed_16542 1 0 decap_w0
xfeed_16541 1 0 decap_w0
xfeed_16540 1 0 decap_w0
xfeed_12239 1 0 decap_w0
xfeed_12238 1 0 decap_w0
xfeed_12237 1 0 decap_w0
xfeed_12236 1 0 decap_w0
xfeed_12235 1 0 decap_w0
xfeed_12234 1 0 decap_w0
xfeed_12233 1 0 decap_w0
xfeed_12232 1 0 decap_w0
xfeed_12231 1 0 decap_w0
xfeed_12230 1 0 decap_w0
xfeed_11709 1 0 decap_w0
xfeed_11708 1 0 decap_w0
xfeed_11707 1 0 decap_w0
xfeed_11706 1 0 decap_w0
xfeed_11705 1 0 decap_w0
xfeed_11704 1 0 decap_w0
xfeed_11703 1 0 decap_w0
xfeed_11702 1 0 decap_w0
xfeed_11701 1 0 decap_w0
xfeed_11700 1 0 decap_w0
xfeed_28009 1 0 decap_w0
xfeed_28008 1 0 decap_w0
xfeed_28007 1 0 decap_w0
xfeed_28006 1 0 decap_w0
xfeed_28005 1 0 decap_w0
xfeed_28004 1 0 decap_w0
xfeed_28003 1 0 decap_w0
xfeed_28002 1 0 decap_w0
xfeed_28001 1 0 decap_w0
xfeed_28000 1 0 decap_w0
xfeed_23085 1 0 decap_w0
xfeed_23084 1 0 decap_w0
xfeed_23083 1 0 decap_w0
xfeed_23082 1 0 decap_w0
xfeed_23081 1 0 decap_w0
xfeed_23080 1 0 decap_w0
xfeed_9819 1 0 decap_w0
xfeed_9818 1 0 decap_w0
xfeed_9817 1 0 decap_w0
xfeed_9816 1 0 decap_w0
xfeed_9815 1 0 decap_w0
xfeed_9814 1 0 decap_w0
xfeed_9813 1 0 decap_w0
xfeed_9812 1 0 decap_w0
xfeed_9811 1 0 decap_w0
xfeed_9810 1 0 decap_w0
xfeed_6039 1 0 decap_w0
xfeed_6038 1 0 decap_w0
xfeed_6037 1 0 decap_w0
xfeed_6036 1 0 decap_w0
xfeed_6035 1 0 decap_w0
xfeed_6034 1 0 decap_w0
xfeed_6033 1 0 decap_w0
xfeed_6032 1 0 decap_w0
xfeed_6031 1 0 decap_w0
xfeed_6030 1 0 decap_w0
xfeed_5509 1 0 decap_w0
xfeed_5508 1 0 decap_w0
xfeed_5507 1 0 decap_w0
xfeed_5506 1 0 decap_w0
xfeed_5505 1 0 decap_w0
xfeed_5504 1 0 decap_w0
xfeed_5503 1 0 decap_w0
xfeed_5502 1 0 decap_w0
xfeed_5501 1 0 decap_w0
xfeed_5500 1 0 decap_w0
xfeed_4899 1 0 decap_w0
xfeed_4898 1 0 decap_w0
xfeed_4897 1 0 decap_w0
xfeed_4896 1 0 decap_w0
xfeed_4895 1 0 decap_w0
xfeed_4894 1 0 decap_w0
xfeed_4893 1 0 decap_w0
xfeed_4892 1 0 decap_w0
xfeed_4891 1 0 decap_w0
xfeed_4890 1 0 decap_w0
xfeed_27399 1 0 decap_w0
xfeed_27398 1 0 decap_w0
xfeed_27397 1 0 decap_w0
xfeed_27396 1 0 decap_w0
xfeed_27395 1 0 decap_w0
xfeed_27394 1 0 decap_w0
xfeed_27393 1 0 decap_w0
xfeed_27392 1 0 decap_w0
xfeed_27391 1 0 decap_w0
xfeed_27390 1 0 decap_w0
xfeed_26869 1 0 decap_w0
xfeed_26868 1 0 decap_w0
xfeed_26867 1 0 decap_w0
xfeed_26866 1 0 decap_w0
xfeed_26865 1 0 decap_w0
xfeed_26864 1 0 decap_w0
xfeed_26863 1 0 decap_w0
xfeed_26862 1 0 decap_w0
xfeed_26861 1 0 decap_w0
xfeed_26860 1 0 decap_w0
xfeed_23089 1 0 decap_w0
xfeed_23088 1 0 decap_w0
xfeed_23087 1 0 decap_w0
xfeed_23086 1 0 decap_w0
xfeed_22559 1 0 decap_w0
xfeed_22558 1 0 decap_w0
xfeed_22557 1 0 decap_w0
xfeed_22556 1 0 decap_w0
xfeed_22555 1 0 decap_w0
xfeed_22554 1 0 decap_w0
xfeed_22553 1 0 decap_w0
xfeed_22552 1 0 decap_w0
xfeed_22551 1 0 decap_w0
xfeed_22550 1 0 decap_w0
xfeed_17089 1 0 decap_w0
xfeed_17088 1 0 decap_w0
xfeed_17087 1 0 decap_w0
xfeed_17086 1 0 decap_w0
xfeed_17085 1 0 decap_w0
xfeed_17084 1 0 decap_w0
xfeed_17083 1 0 decap_w0
xfeed_17082 1 0 decap_w0
xfeed_17081 1 0 decap_w0
xfeed_17080 1 0 decap_w0
xfeed_16559 1 0 decap_w0
xfeed_16558 1 0 decap_w0
xfeed_16557 1 0 decap_w0
xfeed_16556 1 0 decap_w0
xfeed_16555 1 0 decap_w0
xfeed_16554 1 0 decap_w0
xfeed_16553 1 0 decap_w0
xfeed_16552 1 0 decap_w0
xfeed_16551 1 0 decap_w0
xfeed_16550 1 0 decap_w0
xfeed_12249 1 0 decap_w0
xfeed_12248 1 0 decap_w0
xfeed_12247 1 0 decap_w0
xfeed_12246 1 0 decap_w0
xfeed_12245 1 0 decap_w0
xfeed_12244 1 0 decap_w0
xfeed_12243 1 0 decap_w0
xfeed_12242 1 0 decap_w0
xfeed_12241 1 0 decap_w0
xfeed_12240 1 0 decap_w0
xfeed_11719 1 0 decap_w0
xfeed_11718 1 0 decap_w0
xfeed_11717 1 0 decap_w0
xfeed_11716 1 0 decap_w0
xfeed_11715 1 0 decap_w0
xfeed_11714 1 0 decap_w0
xfeed_11713 1 0 decap_w0
xfeed_11712 1 0 decap_w0
xfeed_11711 1 0 decap_w0
xfeed_11710 1 0 decap_w0
xfeed_28019 1 0 decap_w0
xfeed_28018 1 0 decap_w0
xfeed_28017 1 0 decap_w0
xfeed_28016 1 0 decap_w0
xfeed_28015 1 0 decap_w0
xfeed_28014 1 0 decap_w0
xfeed_28013 1 0 decap_w0
xfeed_28012 1 0 decap_w0
xfeed_28011 1 0 decap_w0
xfeed_28010 1 0 decap_w0
xfeed_23092 1 0 decap_w0
xfeed_23091 1 0 decap_w0
xfeed_23090 1 0 decap_w0
xfeed_9829 1 0 decap_w0
xfeed_9828 1 0 decap_w0
xfeed_9827 1 0 decap_w0
xfeed_9826 1 0 decap_w0
xfeed_9825 1 0 decap_w0
xfeed_9824 1 0 decap_w0
xfeed_9823 1 0 decap_w0
xfeed_9822 1 0 decap_w0
xfeed_9821 1 0 decap_w0
xfeed_9820 1 0 decap_w0
xfeed_6049 1 0 decap_w0
xfeed_6048 1 0 decap_w0
xfeed_6047 1 0 decap_w0
xfeed_6046 1 0 decap_w0
xfeed_6045 1 0 decap_w0
xfeed_6044 1 0 decap_w0
xfeed_6043 1 0 decap_w0
xfeed_6042 1 0 decap_w0
xfeed_6041 1 0 decap_w0
xfeed_6040 1 0 decap_w0
xfeed_5519 1 0 decap_w0
xfeed_5518 1 0 decap_w0
xfeed_5517 1 0 decap_w0
xfeed_5516 1 0 decap_w0
xfeed_5515 1 0 decap_w0
xfeed_5514 1 0 decap_w0
xfeed_5513 1 0 decap_w0
xfeed_5512 1 0 decap_w0
xfeed_5511 1 0 decap_w0
xfeed_5510 1 0 decap_w0
xfeed_1200 1 0 decap_w0
xfeed_1201 1 0 decap_w0
xfeed_1202 1 0 decap_w0
xfeed_1203 1 0 decap_w0
xfeed_1204 1 0 decap_w0
xfeed_1205 1 0 decap_w0
xfeed_1206 1 0 decap_w0
xfeed_1207 1 0 decap_w0
xfeed_1208 1 0 decap_w0
xfeed_1209 1 0 decap_w0
xfeed_26879 1 0 decap_w0
xfeed_26878 1 0 decap_w0
xfeed_26877 1 0 decap_w0
xfeed_26876 1 0 decap_w0
xfeed_26875 1 0 decap_w0
xfeed_26874 1 0 decap_w0
xfeed_26873 1 0 decap_w0
xfeed_26872 1 0 decap_w0
xfeed_26871 1 0 decap_w0
xfeed_26870 1 0 decap_w0
xfeed_23099 1 0 decap_w0
xfeed_23098 1 0 decap_w0
xfeed_23097 1 0 decap_w0
xfeed_23096 1 0 decap_w0
xfeed_23095 1 0 decap_w0
xfeed_23094 1 0 decap_w0
xfeed_23093 1 0 decap_w0
xfeed_22569 1 0 decap_w0
xfeed_22568 1 0 decap_w0
xfeed_22567 1 0 decap_w0
xfeed_22566 1 0 decap_w0
xfeed_22565 1 0 decap_w0
xfeed_22564 1 0 decap_w0
xfeed_22563 1 0 decap_w0
xfeed_22562 1 0 decap_w0
xfeed_22561 1 0 decap_w0
xfeed_22560 1 0 decap_w0
xfeed_17099 1 0 decap_w0
xfeed_17098 1 0 decap_w0
xfeed_17097 1 0 decap_w0
xfeed_17096 1 0 decap_w0
xfeed_17095 1 0 decap_w0
xfeed_17094 1 0 decap_w0
xfeed_17093 1 0 decap_w0
xfeed_17092 1 0 decap_w0
xfeed_17091 1 0 decap_w0
xfeed_17090 1 0 decap_w0
xfeed_16569 1 0 decap_w0
xfeed_16568 1 0 decap_w0
xfeed_16567 1 0 decap_w0
xfeed_16566 1 0 decap_w0
xfeed_16565 1 0 decap_w0
xfeed_16564 1 0 decap_w0
xfeed_16563 1 0 decap_w0
xfeed_16562 1 0 decap_w0
xfeed_16561 1 0 decap_w0
xfeed_16560 1 0 decap_w0
xfeed_12259 1 0 decap_w0
xfeed_12258 1 0 decap_w0
xfeed_12257 1 0 decap_w0
xfeed_12256 1 0 decap_w0
xfeed_12255 1 0 decap_w0
xfeed_12254 1 0 decap_w0
xfeed_12253 1 0 decap_w0
xfeed_12252 1 0 decap_w0
xfeed_12251 1 0 decap_w0
xfeed_12250 1 0 decap_w0
xfeed_11729 1 0 decap_w0
xfeed_11728 1 0 decap_w0
xfeed_11727 1 0 decap_w0
xfeed_11726 1 0 decap_w0
xfeed_11725 1 0 decap_w0
xfeed_11724 1 0 decap_w0
xfeed_11723 1 0 decap_w0
xfeed_11722 1 0 decap_w0
xfeed_11721 1 0 decap_w0
xfeed_11720 1 0 decap_w0
xfeed_28029 1 0 decap_w0
xfeed_28028 1 0 decap_w0
xfeed_28027 1 0 decap_w0
xfeed_28026 1 0 decap_w0
xfeed_28025 1 0 decap_w0
xfeed_28024 1 0 decap_w0
xfeed_28023 1 0 decap_w0
xfeed_28022 1 0 decap_w0
xfeed_28021 1 0 decap_w0
xfeed_28020 1 0 decap_w0
xfeed_9839 1 0 decap_w0
xfeed_9838 1 0 decap_w0
xfeed_9837 1 0 decap_w0
xfeed_9836 1 0 decap_w0
xfeed_9835 1 0 decap_w0
xfeed_9834 1 0 decap_w0
xfeed_9833 1 0 decap_w0
xfeed_9832 1 0 decap_w0
xfeed_9831 1 0 decap_w0
xfeed_9830 1 0 decap_w0
xfeed_6059 1 0 decap_w0
xfeed_6058 1 0 decap_w0
xfeed_6057 1 0 decap_w0
xfeed_6056 1 0 decap_w0
xfeed_6055 1 0 decap_w0
xfeed_6054 1 0 decap_w0
xfeed_6053 1 0 decap_w0
xfeed_6052 1 0 decap_w0
xfeed_6051 1 0 decap_w0
xfeed_6050 1 0 decap_w0
xfeed_5529 1 0 decap_w0
xfeed_5528 1 0 decap_w0
xfeed_5527 1 0 decap_w0
xfeed_5526 1 0 decap_w0
xfeed_5525 1 0 decap_w0
xfeed_5524 1 0 decap_w0
xfeed_5523 1 0 decap_w0
xfeed_5522 1 0 decap_w0
xfeed_5521 1 0 decap_w0
xfeed_5520 1 0 decap_w0
xfeed_1210 1 0 decap_w0
xfeed_1211 1 0 decap_w0
xfeed_1212 1 0 decap_w0
xfeed_1213 1 0 decap_w0
xfeed_1214 1 0 decap_w0
xfeed_1215 1 0 decap_w0
xfeed_1216 1 0 decap_w0
xfeed_1217 1 0 decap_w0
xfeed_1218 1 0 decap_w0
xfeed_1219 1 0 decap_w0
xfeed_26889 1 0 decap_w0
xfeed_26888 1 0 decap_w0
xfeed_26887 1 0 decap_w0
xfeed_26886 1 0 decap_w0
xfeed_26885 1 0 decap_w0
xfeed_26884 1 0 decap_w0
xfeed_26883 1 0 decap_w0
xfeed_26882 1 0 decap_w0
xfeed_26881 1 0 decap_w0
xfeed_26880 1 0 decap_w0
xfeed_22579 1 0 decap_w0
xfeed_22578 1 0 decap_w0
xfeed_22577 1 0 decap_w0
xfeed_22576 1 0 decap_w0
xfeed_22575 1 0 decap_w0
xfeed_22574 1 0 decap_w0
xfeed_22573 1 0 decap_w0
xfeed_22572 1 0 decap_w0
xfeed_22571 1 0 decap_w0
xfeed_22570 1 0 decap_w0
xfeed_16579 1 0 decap_w0
xfeed_16578 1 0 decap_w0
xfeed_16577 1 0 decap_w0
xfeed_16576 1 0 decap_w0
xfeed_16575 1 0 decap_w0
xfeed_16574 1 0 decap_w0
xfeed_16573 1 0 decap_w0
xfeed_16572 1 0 decap_w0
xfeed_16571 1 0 decap_w0
xfeed_16570 1 0 decap_w0
xfeed_12269 1 0 decap_w0
xfeed_12268 1 0 decap_w0
xfeed_12267 1 0 decap_w0
xfeed_12266 1 0 decap_w0
xfeed_12265 1 0 decap_w0
xfeed_12264 1 0 decap_w0
xfeed_12263 1 0 decap_w0
xfeed_12262 1 0 decap_w0
xfeed_12261 1 0 decap_w0
xfeed_12260 1 0 decap_w0
xfeed_11739 1 0 decap_w0
xfeed_11738 1 0 decap_w0
xfeed_11737 1 0 decap_w0
xfeed_11736 1 0 decap_w0
xfeed_11735 1 0 decap_w0
xfeed_11734 1 0 decap_w0
xfeed_11733 1 0 decap_w0
xfeed_11732 1 0 decap_w0
xfeed_11731 1 0 decap_w0
xfeed_11730 1 0 decap_w0
xfeed_28039 1 0 decap_w0
xfeed_28038 1 0 decap_w0
xfeed_28037 1 0 decap_w0
xfeed_28036 1 0 decap_w0
xfeed_28035 1 0 decap_w0
xfeed_28034 1 0 decap_w0
xfeed_28033 1 0 decap_w0
xfeed_28032 1 0 decap_w0
xfeed_28031 1 0 decap_w0
xfeed_28030 1 0 decap_w0
xfeed_27504 1 0 decap_w0
xfeed_27503 1 0 decap_w0
xfeed_27502 1 0 decap_w0
xfeed_27501 1 0 decap_w0
xfeed_27500 1 0 decap_w0
xfeed_9849 1 0 decap_w0
xfeed_9848 1 0 decap_w0
xfeed_9847 1 0 decap_w0
xfeed_9846 1 0 decap_w0
xfeed_9845 1 0 decap_w0
xfeed_9844 1 0 decap_w0
xfeed_9843 1 0 decap_w0
xfeed_9842 1 0 decap_w0
xfeed_9841 1 0 decap_w0
xfeed_9840 1 0 decap_w0
xfeed_6069 1 0 decap_w0
xfeed_6068 1 0 decap_w0
xfeed_6067 1 0 decap_w0
xfeed_6066 1 0 decap_w0
xfeed_6065 1 0 decap_w0
xfeed_6064 1 0 decap_w0
xfeed_6063 1 0 decap_w0
xfeed_6062 1 0 decap_w0
xfeed_6061 1 0 decap_w0
xfeed_6060 1 0 decap_w0
xfeed_5539 1 0 decap_w0
xfeed_5538 1 0 decap_w0
xfeed_5537 1 0 decap_w0
xfeed_5536 1 0 decap_w0
xfeed_5535 1 0 decap_w0
xfeed_5534 1 0 decap_w0
xfeed_5533 1 0 decap_w0
xfeed_5532 1 0 decap_w0
xfeed_5531 1 0 decap_w0
xfeed_5530 1 0 decap_w0
xfeed_1220 1 0 decap_w0
xfeed_1221 1 0 decap_w0
xfeed_1222 1 0 decap_w0
xfeed_1223 1 0 decap_w0
xfeed_1224 1 0 decap_w0
xfeed_1225 1 0 decap_w0
xfeed_1226 1 0 decap_w0
xfeed_1227 1 0 decap_w0
xfeed_1228 1 0 decap_w0
xfeed_1229 1 0 decap_w0
xfeed_27509 1 0 decap_w0
xfeed_27508 1 0 decap_w0
xfeed_27507 1 0 decap_w0
xfeed_27506 1 0 decap_w0
xfeed_27505 1 0 decap_w0
xfeed_26899 1 0 decap_w0
xfeed_26898 1 0 decap_w0
xfeed_26897 1 0 decap_w0
xfeed_26896 1 0 decap_w0
xfeed_26895 1 0 decap_w0
xfeed_26894 1 0 decap_w0
xfeed_26893 1 0 decap_w0
xfeed_26892 1 0 decap_w0
xfeed_26891 1 0 decap_w0
xfeed_26890 1 0 decap_w0
xfeed_22589 1 0 decap_w0
xfeed_22588 1 0 decap_w0
xfeed_22587 1 0 decap_w0
xfeed_22586 1 0 decap_w0
xfeed_22585 1 0 decap_w0
xfeed_22584 1 0 decap_w0
xfeed_22583 1 0 decap_w0
xfeed_22582 1 0 decap_w0
xfeed_22581 1 0 decap_w0
xfeed_22580 1 0 decap_w0
xfeed_16589 1 0 decap_w0
xfeed_16588 1 0 decap_w0
xfeed_16587 1 0 decap_w0
xfeed_16586 1 0 decap_w0
xfeed_16585 1 0 decap_w0
xfeed_16584 1 0 decap_w0
xfeed_16583 1 0 decap_w0
xfeed_16582 1 0 decap_w0
xfeed_16581 1 0 decap_w0
xfeed_16580 1 0 decap_w0
xfeed_12279 1 0 decap_w0
xfeed_12278 1 0 decap_w0
xfeed_12277 1 0 decap_w0
xfeed_12276 1 0 decap_w0
xfeed_12275 1 0 decap_w0
xfeed_12274 1 0 decap_w0
xfeed_12273 1 0 decap_w0
xfeed_12272 1 0 decap_w0
xfeed_12271 1 0 decap_w0
xfeed_12270 1 0 decap_w0
xfeed_11749 1 0 decap_w0
xfeed_11748 1 0 decap_w0
xfeed_11747 1 0 decap_w0
xfeed_11746 1 0 decap_w0
xfeed_11745 1 0 decap_w0
xfeed_11744 1 0 decap_w0
xfeed_11743 1 0 decap_w0
xfeed_11742 1 0 decap_w0
xfeed_11741 1 0 decap_w0
xfeed_11740 1 0 decap_w0
xfeed_28049 1 0 decap_w0
xfeed_28048 1 0 decap_w0
xfeed_28047 1 0 decap_w0
xfeed_28046 1 0 decap_w0
xfeed_28045 1 0 decap_w0
xfeed_28044 1 0 decap_w0
xfeed_28043 1 0 decap_w0
xfeed_28042 1 0 decap_w0
xfeed_28041 1 0 decap_w0
xfeed_28040 1 0 decap_w0
xfeed_27511 1 0 decap_w0
xfeed_27510 1 0 decap_w0
xfeed_23209 1 0 decap_w0
xfeed_23208 1 0 decap_w0
xfeed_23207 1 0 decap_w0
xfeed_23206 1 0 decap_w0
xfeed_23205 1 0 decap_w0
xfeed_23204 1 0 decap_w0
xfeed_23203 1 0 decap_w0
xfeed_23202 1 0 decap_w0
xfeed_23201 1 0 decap_w0
xfeed_23200 1 0 decap_w0
xfeed_9859 1 0 decap_w0
xfeed_9858 1 0 decap_w0
xfeed_9857 1 0 decap_w0
xfeed_9856 1 0 decap_w0
xfeed_9855 1 0 decap_w0
xfeed_9854 1 0 decap_w0
xfeed_9853 1 0 decap_w0
xfeed_9852 1 0 decap_w0
xfeed_9851 1 0 decap_w0
xfeed_9850 1 0 decap_w0
xfeed_6079 1 0 decap_w0
xfeed_6078 1 0 decap_w0
xfeed_6077 1 0 decap_w0
xfeed_6076 1 0 decap_w0
xfeed_6075 1 0 decap_w0
xfeed_6074 1 0 decap_w0
xfeed_6073 1 0 decap_w0
xfeed_6072 1 0 decap_w0
xfeed_6071 1 0 decap_w0
xfeed_6070 1 0 decap_w0
xfeed_5549 1 0 decap_w0
xfeed_5548 1 0 decap_w0
xfeed_5547 1 0 decap_w0
xfeed_5546 1 0 decap_w0
xfeed_5545 1 0 decap_w0
xfeed_5544 1 0 decap_w0
xfeed_5543 1 0 decap_w0
xfeed_5542 1 0 decap_w0
xfeed_5541 1 0 decap_w0
xfeed_5540 1 0 decap_w0
xfeed_1230 1 0 decap_w0
xfeed_1231 1 0 decap_w0
xfeed_1232 1 0 decap_w0
xfeed_1233 1 0 decap_w0
xfeed_1234 1 0 decap_w0
xfeed_1235 1 0 decap_w0
xfeed_1236 1 0 decap_w0
xfeed_1237 1 0 decap_w0
xfeed_1238 1 0 decap_w0
xfeed_1239 1 0 decap_w0
xfeed_27519 1 0 decap_w0
xfeed_27518 1 0 decap_w0
xfeed_27517 1 0 decap_w0
xfeed_27516 1 0 decap_w0
xfeed_27515 1 0 decap_w0
xfeed_27514 1 0 decap_w0
xfeed_27513 1 0 decap_w0
xfeed_27512 1 0 decap_w0
xfeed_22599 1 0 decap_w0
xfeed_22598 1 0 decap_w0
xfeed_22597 1 0 decap_w0
xfeed_22596 1 0 decap_w0
xfeed_22595 1 0 decap_w0
xfeed_22594 1 0 decap_w0
xfeed_22593 1 0 decap_w0
xfeed_22592 1 0 decap_w0
xfeed_22591 1 0 decap_w0
xfeed_22590 1 0 decap_w0
xfeed_17209 1 0 decap_w0
xfeed_17208 1 0 decap_w0
xfeed_17207 1 0 decap_w0
xfeed_17206 1 0 decap_w0
xfeed_17205 1 0 decap_w0
xfeed_17204 1 0 decap_w0
xfeed_17203 1 0 decap_w0
xfeed_17202 1 0 decap_w0
xfeed_17201 1 0 decap_w0
xfeed_17200 1 0 decap_w0
xfeed_16599 1 0 decap_w0
xfeed_16598 1 0 decap_w0
xfeed_16597 1 0 decap_w0
xfeed_16596 1 0 decap_w0
xfeed_16595 1 0 decap_w0
xfeed_16594 1 0 decap_w0
xfeed_16593 1 0 decap_w0
xfeed_16592 1 0 decap_w0
xfeed_16591 1 0 decap_w0
xfeed_16590 1 0 decap_w0
xfeed_12289 1 0 decap_w0
xfeed_12288 1 0 decap_w0
xfeed_12287 1 0 decap_w0
xfeed_12286 1 0 decap_w0
xfeed_12285 1 0 decap_w0
xfeed_12284 1 0 decap_w0
xfeed_12283 1 0 decap_w0
xfeed_12282 1 0 decap_w0
xfeed_12281 1 0 decap_w0
xfeed_12280 1 0 decap_w0
xfeed_11759 1 0 decap_w0
xfeed_11758 1 0 decap_w0
xfeed_11757 1 0 decap_w0
xfeed_11756 1 0 tie
xfeed_11755 1 0 decap_w0
xfeed_11754 1 0 decap_w0
xfeed_11753 1 0 decap_w0
xfeed_11752 1 0 decap_w0
xfeed_11751 1 0 decap_w0
xfeed_11750 1 0 decap_w0
xfeed_28057 1 0 decap_w0
xfeed_28056 1 0 decap_w0
xfeed_28055 1 0 decap_w0
xfeed_28054 1 0 decap_w0
xfeed_28053 1 0 decap_w0
xfeed_28052 1 0 decap_w0
xfeed_28051 1 0 decap_w0
xfeed_28050 1 0 decap_w0
xfeed_23218 1 0 decap_w0
xfeed_23217 1 0 decap_w0
xfeed_23216 1 0 decap_w0
xfeed_23215 1 0 decap_w0
xfeed_23214 1 0 decap_w0
xfeed_23213 1 0 decap_w0
xfeed_23212 1 0 decap_w0
xfeed_23211 1 0 decap_w0
xfeed_23210 1 0 decap_w0
xfeed_9869 1 0 decap_w0
xfeed_9868 1 0 decap_w0
xfeed_9867 1 0 decap_w0
xfeed_9866 1 0 decap_w0
xfeed_9865 1 0 decap_w0
xfeed_9864 1 0 decap_w0
xfeed_9863 1 0 decap_w0
xfeed_9862 1 0 decap_w0
xfeed_9861 1 0 decap_w0
xfeed_9860 1 0 decap_w0
xfeed_6089 1 0 decap_w0
xfeed_6088 1 0 decap_w0
xfeed_6087 1 0 decap_w0
xfeed_6086 1 0 decap_w0
xfeed_6085 1 0 decap_w0
xfeed_6084 1 0 decap_w0
xfeed_6083 1 0 decap_w0
xfeed_6082 1 0 decap_w0
xfeed_6081 1 0 decap_w0
xfeed_6080 1 0 decap_w0
xfeed_5559 1 0 decap_w0
xfeed_5558 1 0 decap_w0
xfeed_5557 1 0 decap_w0
xfeed_5556 1 0 decap_w0
xfeed_5555 1 0 decap_w0
xfeed_5554 1 0 decap_w0
xfeed_5553 1 0 decap_w0
xfeed_5552 1 0 decap_w0
xfeed_5551 1 0 decap_w0
xfeed_5550 1 0 decap_w0
xfeed_1240 1 0 decap_w0
xfeed_1241 1 0 decap_w0
xfeed_1242 1 0 decap_w0
xfeed_1243 1 0 decap_w0
xfeed_1244 1 0 decap_w0
xfeed_1245 1 0 decap_w0
xfeed_1246 1 0 decap_w0
xfeed_1247 1 0 decap_w0
xfeed_1248 1 0 decap_w0
xfeed_1249 1 0 decap_w0
xfeed_28059 1 0 decap_w0
xfeed_28058 1 0 decap_w0
xfeed_27529 1 0 decap_w0
xfeed_27528 1 0 decap_w0
xfeed_27527 1 0 decap_w0
xfeed_27526 1 0 decap_w0
xfeed_27525 1 0 decap_w0
xfeed_27524 1 0 decap_w0
xfeed_27523 1 0 decap_w0
xfeed_27522 1 0 decap_w0
xfeed_27521 1 0 decap_w0
xfeed_27520 1 0 decap_w0
xfeed_23219 1 0 decap_w0
xfeed_17219 1 0 decap_w0
xfeed_17218 1 0 decap_w0
xfeed_17217 1 0 decap_w0
xfeed_17216 1 0 decap_w0
xfeed_17215 1 0 decap_w0
xfeed_17214 1 0 decap_w0
xfeed_17213 1 0 decap_w0
xfeed_17212 1 0 decap_w0
xfeed_17211 1 0 decap_w0
xfeed_17210 1 0 decap_w0
xfeed_12299 1 0 decap_w0
xfeed_12298 1 0 decap_w0
xfeed_12297 1 0 decap_w0
xfeed_12296 1 0 decap_w0
xfeed_12295 1 0 decap_w0
xfeed_12294 1 0 decap_w0
xfeed_12293 1 0 decap_w0
xfeed_12292 1 0 decap_w0
xfeed_12291 1 0 decap_w0
xfeed_12290 1 0 decap_w0
xfeed_11769 1 0 decap_w0
xfeed_11768 1 0 decap_w0
xfeed_11767 1 0 decap_w0
xfeed_11766 1 0 decap_w0
xfeed_11765 1 0 decap_w0
xfeed_11764 1 0 decap_w0
xfeed_11763 1 0 decap_w0
xfeed_11762 1 0 decap_w0
xfeed_11761 1 0 decap_w0
xfeed_11760 1 0 decap_w0
xfeed_28064 1 0 decap_w0
xfeed_28063 1 0 decap_w0
xfeed_28062 1 0 decap_w0
xfeed_28061 1 0 decap_w0
xfeed_28060 1 0 decap_w0
xfeed_23225 1 0 decap_w0
xfeed_23224 1 0 decap_w0
xfeed_23223 1 0 decap_w0
xfeed_23222 1 0 decap_w0
xfeed_23221 1 0 decap_w0
xfeed_23220 1 0 decap_w0
xfeed_9879 1 0 decap_w0
xfeed_9878 1 0 decap_w0
xfeed_9877 1 0 decap_w0
xfeed_9876 1 0 decap_w0
xfeed_9875 1 0 decap_w0
xfeed_9874 1 0 decap_w0
xfeed_9873 1 0 decap_w0
xfeed_9872 1 0 decap_w0
xfeed_9871 1 0 decap_w0
xfeed_9870 1 0 decap_w0
xfeed_6099 1 0 decap_w0
xfeed_6098 1 0 decap_w0
xfeed_6097 1 0 decap_w0
xfeed_6096 1 0 decap_w0
xfeed_6095 1 0 decap_w0
xfeed_6094 1 0 decap_w0
xfeed_6093 1 0 decap_w0
xfeed_6092 1 0 decap_w0
xfeed_6091 1 0 decap_w0
xfeed_6090 1 0 decap_w0
xfeed_5569 1 0 decap_w0
xfeed_5568 1 0 decap_w0
xfeed_5567 1 0 decap_w0
xfeed_5566 1 0 decap_w0
xfeed_5565 1 0 decap_w0
xfeed_5564 1 0 decap_w0
xfeed_5563 1 0 decap_w0
xfeed_5562 1 0 decap_w0
xfeed_5561 1 0 decap_w0
xfeed_5560 1 0 decap_w0
xfeed_1250 1 0 decap_w0
xfeed_1251 1 0 decap_w0
xfeed_1252 1 0 decap_w0
xfeed_1253 1 0 decap_w0
xfeed_1254 1 0 decap_w0
xfeed_1255 1 0 decap_w0
xfeed_1256 1 0 decap_w0
xfeed_1257 1 0 decap_w0
xfeed_1258 1 0 decap_w0
xfeed_1259 1 0 decap_w0
xfeed_28069 1 0 decap_w0
xfeed_28068 1 0 decap_w0
xfeed_28067 1 0 decap_w0
xfeed_28066 1 0 decap_w0
xfeed_28065 1 0 decap_w0
xfeed_27539 1 0 decap_w0
xfeed_27538 1 0 decap_w0
xfeed_27537 1 0 decap_w0
xfeed_27536 1 0 decap_w0
xfeed_27535 1 0 decap_w0
xfeed_27534 1 0 decap_w0
xfeed_27533 1 0 decap_w0
xfeed_27532 1 0 decap_w0
xfeed_27531 1 0 decap_w0
xfeed_27530 1 0 decap_w0
xfeed_23229 1 0 decap_w0
xfeed_23228 1 0 decap_w0
xfeed_23227 1 0 decap_w0
xfeed_23226 1 0 decap_w0
xfeed_17229 1 0 decap_w0
xfeed_17228 1 0 decap_w0
xfeed_17227 1 0 decap_w0
xfeed_17226 1 0 decap_w0
xfeed_17225 1 0 decap_w0
xfeed_17224 1 0 tie
xfeed_17223 1 0 decap_w0
xfeed_17222 1 0 decap_w0
xfeed_17221 1 0 decap_w0
xfeed_17220 1 0 decap_w0
xfeed_11779 1 0 decap_w0
xfeed_11778 1 0 decap_w0
xfeed_11777 1 0 decap_w0
xfeed_11776 1 0 decap_w0
xfeed_11775 1 0 decap_w0
xfeed_11774 1 0 decap_w0
xfeed_11773 1 0 decap_w0
xfeed_11772 1 0 decap_w0
xfeed_11771 1 0 decap_w0
xfeed_11770 1 0 decap_w0
xfeed_28071 1 0 decap_w0
xfeed_28070 1 0 decap_w0
xfeed_23232 1 0 decap_w0
xfeed_23231 1 0 decap_w0
xfeed_23230 1 0 decap_w0
xfeed_9889 1 0 decap_w0
xfeed_9888 1 0 decap_w0
xfeed_9887 1 0 decap_w0
xfeed_9886 1 0 decap_w0
xfeed_9885 1 0 decap_w0
xfeed_9884 1 0 decap_w0
xfeed_9883 1 0 decap_w0
xfeed_9882 1 0 decap_w0
xfeed_9881 1 0 decap_w0
xfeed_9880 1 0 decap_w0
xfeed_5579 1 0 decap_w0
xfeed_5578 1 0 decap_w0
xfeed_5577 1 0 decap_w0
xfeed_5576 1 0 decap_w0
xfeed_5575 1 0 decap_w0
xfeed_5574 1 0 decap_w0
xfeed_5573 1 0 decap_w0
xfeed_5572 1 0 decap_w0
xfeed_5571 1 0 decap_w0
xfeed_5570 1 0 decap_w0
xfeed_1260 1 0 decap_w0
xfeed_1261 1 0 decap_w0
xfeed_1262 1 0 decap_w0
xfeed_1263 1 0 decap_w0
xfeed_1264 1 0 decap_w0
xfeed_1265 1 0 decap_w0
xfeed_1266 1 0 decap_w0
xfeed_1267 1 0 decap_w0
xfeed_1268 1 0 decap_w0
xfeed_1269 1 0 decap_w0
xfeed_28079 1 0 decap_w0
xfeed_28078 1 0 decap_w0
xfeed_28077 1 0 decap_w0
xfeed_28076 1 0 decap_w0
xfeed_28075 1 0 decap_w0
xfeed_28074 1 0 decap_w0
xfeed_28073 1 0 decap_w0
xfeed_28072 1 0 decap_w0
xfeed_27549 1 0 decap_w0
xfeed_27548 1 0 decap_w0
xfeed_27547 1 0 decap_w0
xfeed_27546 1 0 decap_w0
xfeed_27545 1 0 decap_w0
xfeed_27544 1 0 decap_w0
xfeed_27543 1 0 decap_w0
xfeed_27542 1 0 decap_w0
xfeed_27541 1 0 decap_w0
xfeed_27540 1 0 decap_w0
xfeed_23239 1 0 decap_w0
xfeed_23238 1 0 decap_w0
xfeed_23237 1 0 decap_w0
xfeed_23236 1 0 decap_w0
xfeed_23235 1 0 decap_w0
xfeed_23234 1 0 decap_w0
xfeed_23233 1 0 decap_w0
xfeed_22709 1 0 decap_w0
xfeed_22708 1 0 decap_w0
xfeed_22707 1 0 decap_w0
xfeed_22706 1 0 decap_w0
xfeed_22705 1 0 decap_w0
xfeed_22704 1 0 decap_w0
xfeed_22703 1 0 decap_w0
xfeed_22702 1 0 decap_w0
xfeed_22701 1 0 decap_w0
xfeed_22700 1 0 decap_w0
xfeed_17239 1 0 decap_w0
xfeed_17238 1 0 decap_w0
xfeed_17237 1 0 decap_w0
xfeed_17236 1 0 decap_w0
xfeed_17235 1 0 decap_w0
xfeed_17234 1 0 decap_w0
xfeed_17233 1 0 decap_w0
xfeed_17232 1 0 decap_w0
xfeed_17231 1 0 decap_w0
xfeed_17230 1 0 decap_w0
xfeed_16709 1 0 decap_w0
xfeed_16708 1 0 decap_w0
xfeed_16707 1 0 decap_w0
xfeed_16706 1 0 decap_w0
xfeed_16705 1 0 decap_w0
xfeed_16704 1 0 decap_w0
xfeed_16703 1 0 decap_w0
xfeed_16702 1 0 decap_w0
xfeed_16701 1 0 decap_w0
xfeed_16700 1 0 decap_w0
xfeed_11789 1 0 decap_w0
xfeed_11788 1 0 decap_w0
xfeed_11787 1 0 decap_w0
xfeed_11786 1 0 decap_w0
xfeed_11785 1 0 decap_w0
xfeed_11784 1 0 decap_w0
xfeed_11783 1 0 decap_w0
xfeed_11782 1 0 decap_w0
xfeed_11781 1 0 decap_w0
xfeed_11780 1 0 decap_w0
xfeed_9899 1 0 decap_w0
xfeed_9898 1 0 decap_w0
xfeed_9897 1 0 decap_w0
xfeed_9896 1 0 decap_w0
xfeed_9895 1 0 decap_w0
xfeed_9894 1 0 decap_w0
xfeed_9893 1 0 decap_w0
xfeed_9892 1 0 decap_w0
xfeed_9891 1 0 decap_w0
xfeed_9890 1 0 decap_w0
xfeed_5589 1 0 decap_w0
xfeed_5588 1 0 decap_w0
xfeed_5587 1 0 decap_w0
xfeed_5586 1 0 decap_w0
xfeed_5585 1 0 decap_w0
xfeed_5584 1 0 decap_w0
xfeed_5583 1 0 decap_w0
xfeed_5582 1 0 decap_w0
xfeed_5581 1 0 decap_w0
xfeed_5580 1 0 decap_w0
xfeed_1270 1 0 decap_w0
xfeed_1271 1 0 decap_w0
xfeed_1272 1 0 decap_w0
xfeed_1273 1 0 decap_w0
xfeed_1274 1 0 decap_w0
xfeed_1275 1 0 decap_w0
xfeed_1276 1 0 decap_w0
xfeed_1277 1 0 decap_w0
xfeed_1278 1 0 decap_w0
xfeed_1279 1 0 decap_w0
xfeed_28089 1 0 decap_w0
xfeed_28088 1 0 tie
xfeed_28087 1 0 decap_w0
xfeed_28086 1 0 decap_w0
xfeed_28085 1 0 decap_w0
xfeed_28084 1 0 decap_w0
xfeed_28083 1 0 decap_w0
xfeed_28082 1 0 decap_w0
xfeed_28081 1 0 decap_w0
xfeed_28080 1 0 decap_w0
xfeed_27559 1 0 decap_w0
xfeed_27558 1 0 decap_w0
xfeed_27557 1 0 decap_w0
xfeed_27556 1 0 decap_w0
xfeed_27555 1 0 decap_w0
xfeed_27554 1 0 decap_w0
xfeed_27553 1 0 decap_w0
xfeed_27552 1 0 decap_w0
xfeed_27551 1 0 decap_w0
xfeed_27550 1 0 decap_w0
xfeed_23249 1 0 decap_w0
xfeed_23248 1 0 decap_w0
xfeed_23247 1 0 decap_w0
xfeed_23246 1 0 decap_w0
xfeed_23245 1 0 decap_w0
xfeed_23244 1 0 decap_w0
xfeed_23243 1 0 decap_w0
xfeed_23242 1 0 decap_w0
xfeed_23241 1 0 decap_w0
xfeed_23240 1 0 decap_w0
xfeed_22719 1 0 decap_w0
xfeed_22718 1 0 decap_w0
xfeed_22717 1 0 decap_w0
xfeed_22716 1 0 decap_w0
xfeed_22715 1 0 decap_w0
xfeed_22714 1 0 decap_w0
xfeed_22713 1 0 decap_w0
xfeed_22712 1 0 decap_w0
xfeed_22711 1 0 decap_w0
xfeed_22710 1 0 decap_w0
xfeed_17249 1 0 decap_w0
xfeed_17248 1 0 decap_w0
xfeed_17247 1 0 decap_w0
xfeed_17246 1 0 decap_w0
xfeed_17245 1 0 decap_w0
xfeed_17244 1 0 decap_w0
xfeed_17243 1 0 decap_w0
xfeed_17242 1 0 decap_w0
xfeed_17241 1 0 decap_w0
xfeed_17240 1 0 decap_w0
xfeed_16719 1 0 decap_w0
xfeed_16718 1 0 decap_w0
xfeed_16717 1 0 decap_w0
xfeed_16716 1 0 decap_w0
xfeed_16715 1 0 decap_w0
xfeed_16714 1 0 decap_w0
xfeed_16713 1 0 decap_w0
xfeed_16712 1 0 decap_w0
xfeed_16711 1 0 decap_w0
xfeed_16710 1 0 decap_w0
xfeed_12409 1 0 decap_w0
xfeed_12408 1 0 decap_w0
xfeed_12407 1 0 decap_w0
xfeed_12406 1 0 decap_w0
xfeed_12405 1 0 decap_w0
xfeed_12404 1 0 decap_w0
xfeed_12403 1 0 decap_w0
xfeed_12402 1 0 decap_w0
xfeed_12401 1 0 decap_w0
xfeed_12400 1 0 decap_w0
xfeed_11799 1 0 decap_w0
xfeed_11798 1 0 decap_w0
xfeed_11797 1 0 decap_w0
xfeed_11796 1 0 decap_w0
xfeed_11795 1 0 decap_w0
xfeed_11794 1 0 decap_w0
xfeed_11793 1 0 decap_w0
xfeed_11792 1 0 decap_w0
xfeed_11791 1 0 decap_w0
xfeed_11790 1 0 decap_w0
xfeed_6209 1 0 decap_w0
xfeed_6208 1 0 decap_w0
xfeed_6207 1 0 decap_w0
xfeed_6206 1 0 decap_w0
xfeed_6205 1 0 decap_w0
xfeed_6204 1 0 decap_w0
xfeed_6203 1 0 decap_w0
xfeed_6202 1 0 decap_w0
xfeed_6201 1 0 decap_w0
xfeed_6200 1 0 decap_w0
xfeed_5599 1 0 decap_w0
xfeed_5598 1 0 decap_w0
xfeed_5597 1 0 decap_w0
xfeed_5596 1 0 decap_w0
xfeed_5595 1 0 decap_w0
xfeed_5594 1 0 decap_w0
xfeed_5593 1 0 decap_w0
xfeed_5592 1 0 decap_w0
xfeed_5591 1 0 decap_w0
xfeed_5590 1 0 decap_w0
xfeed_1280 1 0 decap_w0
xfeed_1281 1 0 decap_w0
xfeed_1282 1 0 decap_w0
xfeed_1283 1 0 decap_w0
xfeed_1284 1 0 decap_w0
xfeed_1285 1 0 decap_w0
xfeed_1286 1 0 decap_w0
xfeed_1287 1 0 decap_w0
xfeed_1288 1 0 decap_w0
xfeed_1289 1 0 decap_w0
xfeed_28099 1 0 decap_w0
xfeed_28098 1 0 decap_w0
xfeed_28097 1 0 decap_w0
xfeed_28096 1 0 decap_w0
xfeed_28095 1 0 decap_w0
xfeed_28094 1 0 decap_w0
xfeed_28093 1 0 decap_w0
xfeed_28092 1 0 decap_w0
xfeed_28091 1 0 decap_w0
xfeed_28090 1 0 decap_w0
xfeed_27569 1 0 decap_w0
xfeed_27568 1 0 decap_w0
xfeed_27567 1 0 decap_w0
xfeed_27566 1 0 decap_w0
xfeed_27565 1 0 decap_w0
xfeed_27564 1 0 decap_w0
xfeed_27563 1 0 decap_w0
xfeed_27562 1 0 decap_w0
xfeed_27561 1 0 decap_w0
xfeed_27560 1 0 decap_w0
xfeed_23259 1 0 decap_w0
xfeed_23258 1 0 decap_w0
xfeed_23257 1 0 decap_w0
xfeed_23256 1 0 decap_w0
xfeed_23255 1 0 decap_w0
xfeed_23254 1 0 decap_w0
xfeed_23253 1 0 decap_w0
xfeed_23252 1 0 decap_w0
xfeed_23251 1 0 decap_w0
xfeed_23250 1 0 decap_w0
xfeed_22729 1 0 decap_w0
xfeed_22728 1 0 decap_w0
xfeed_22727 1 0 decap_w0
xfeed_22726 1 0 decap_w0
xfeed_22725 1 0 decap_w0
xfeed_22724 1 0 decap_w0
xfeed_22723 1 0 decap_w0
xfeed_22722 1 0 decap_w0
xfeed_22721 1 0 decap_w0
xfeed_22720 1 0 decap_w0
xfeed_17259 1 0 decap_w0
xfeed_17258 1 0 decap_w0
xfeed_17257 1 0 decap_w0
xfeed_17256 1 0 decap_w0
xfeed_17255 1 0 decap_w0
xfeed_17254 1 0 decap_w0
xfeed_17253 1 0 decap_w0
xfeed_17252 1 0 decap_w0
xfeed_17251 1 0 decap_w0
xfeed_17250 1 0 decap_w0
xfeed_16729 1 0 decap_w0
xfeed_16728 1 0 decap_w0
xfeed_16727 1 0 decap_w0
xfeed_16726 1 0 decap_w0
xfeed_16725 1 0 decap_w0
xfeed_16724 1 0 decap_w0
xfeed_16723 1 0 decap_w0
xfeed_16722 1 0 decap_w0
xfeed_16721 1 0 decap_w0
xfeed_16720 1 0 decap_w0
xfeed_12419 1 0 decap_w0
xfeed_12418 1 0 decap_w0
xfeed_12417 1 0 decap_w0
xfeed_12416 1 0 decap_w0
xfeed_12415 1 0 decap_w0
xfeed_12414 1 0 decap_w0
xfeed_12413 1 0 decap_w0
xfeed_12412 1 0 decap_w0
xfeed_12411 1 0 decap_w0
xfeed_12410 1 0 decap_w0
xfeed_6219 1 0 decap_w0
xfeed_6218 1 0 decap_w0
xfeed_6217 1 0 decap_w0
xfeed_6216 1 0 decap_w0
xfeed_6215 1 0 decap_w0
xfeed_6214 1 0 decap_w0
xfeed_6213 1 0 decap_w0
xfeed_6212 1 0 decap_w0
xfeed_6211 1 0 decap_w0
xfeed_6210 1 0 decap_w0
xfeed_1290 1 0 decap_w0
xfeed_1291 1 0 decap_w0
xfeed_1292 1 0 decap_w0
xfeed_1293 1 0 decap_w0
xfeed_1294 1 0 decap_w0
xfeed_1295 1 0 decap_w0
xfeed_1296 1 0 decap_w0
xfeed_1297 1 0 decap_w0
xfeed_1298 1 0 decap_w0
xfeed_1299 1 0 decap_w0
xfeed_27579 1 0 decap_w0
xfeed_27578 1 0 decap_w0
xfeed_27577 1 0 decap_w0
xfeed_27576 1 0 decap_w0
xfeed_27575 1 0 decap_w0
xfeed_27574 1 0 decap_w0
xfeed_27573 1 0 decap_w0
xfeed_27572 1 0 decap_w0
xfeed_27571 1 0 decap_w0
xfeed_27570 1 0 decap_w0
xfeed_23269 1 0 decap_w0
xfeed_23268 1 0 decap_w0
xfeed_23267 1 0 decap_w0
xfeed_23266 1 0 decap_w0
xfeed_23265 1 0 decap_w0
xfeed_23264 1 0 decap_w0
xfeed_23263 1 0 decap_w0
xfeed_23262 1 0 decap_w0
xfeed_23261 1 0 decap_w0
xfeed_23260 1 0 decap_w0
xfeed_22739 1 0 decap_w0
xfeed_22738 1 0 decap_w0
xfeed_22737 1 0 decap_w0
xfeed_22736 1 0 decap_w0
xfeed_22735 1 0 decap_w0
xfeed_22734 1 0 decap_w0
xfeed_22733 1 0 decap_w0
xfeed_22732 1 0 decap_w0
xfeed_22731 1 0 decap_w0
xfeed_22730 1 0 decap_w0
xfeed_17269 1 0 decap_w0
xfeed_17268 1 0 decap_w0
xfeed_17267 1 0 decap_w0
xfeed_17266 1 0 decap_w0
xfeed_17265 1 0 decap_w0
xfeed_17264 1 0 decap_w0
xfeed_17263 1 0 decap_w0
xfeed_17262 1 0 decap_w0
xfeed_17261 1 0 decap_w0
xfeed_17260 1 0 decap_w0
xfeed_16739 1 0 decap_w0
xfeed_16738 1 0 decap_w0
xfeed_16737 1 0 decap_w0
xfeed_16736 1 0 decap_w0
xfeed_16735 1 0 decap_w0
xfeed_16734 1 0 decap_w0
xfeed_16733 1 0 decap_w0
xfeed_16732 1 0 decap_w0
xfeed_16731 1 0 decap_w0
xfeed_16730 1 0 decap_w0
xfeed_12429 1 0 decap_w0
xfeed_12428 1 0 decap_w0
xfeed_12427 1 0 decap_w0
xfeed_12426 1 0 decap_w0
xfeed_12425 1 0 decap_w0
xfeed_12424 1 0 decap_w0
xfeed_12423 1 0 decap_w0
xfeed_12422 1 0 decap_w0
xfeed_12421 1 0 decap_w0
xfeed_12420 1 0 decap_w0
xfeed_6229 1 0 decap_w0
xfeed_6228 1 0 decap_w0
xfeed_6227 1 0 decap_w0
xfeed_6226 1 0 decap_w0
xfeed_6225 1 0 decap_w0
xfeed_6224 1 0 decap_w0
xfeed_6223 1 0 decap_w0
xfeed_6222 1 0 decap_w0
xfeed_6221 1 0 decap_w0
xfeed_6220 1 0 decap_w0
xfeed_27589 1 0 decap_w0
xfeed_27588 1 0 decap_w0
xfeed_27587 1 0 decap_w0
xfeed_27586 1 0 decap_w0
xfeed_27585 1 0 decap_w0
xfeed_27584 1 0 decap_w0
xfeed_27583 1 0 decap_w0
xfeed_27582 1 0 decap_w0
xfeed_27581 1 0 decap_w0
xfeed_27580 1 0 decap_w0
xfeed_23279 1 0 decap_w0
xfeed_23278 1 0 tie
xfeed_23277 1 0 decap_w0
xfeed_23276 1 0 decap_w0
xfeed_23275 1 0 decap_w0
xfeed_23274 1 0 decap_w0
xfeed_23273 1 0 decap_w0
xfeed_23272 1 0 decap_w0
xfeed_23271 1 0 decap_w0
xfeed_23270 1 0 decap_w0
xfeed_22749 1 0 decap_w0
xfeed_22748 1 0 decap_w0
xfeed_22747 1 0 decap_w0
xfeed_22746 1 0 decap_w0
xfeed_22745 1 0 decap_w0
xfeed_22744 1 0 decap_w0
xfeed_22743 1 0 decap_w0
xfeed_22742 1 0 decap_w0
xfeed_22741 1 0 decap_w0
xfeed_22740 1 0 decap_w0
xfeed_17279 1 0 decap_w0
xfeed_17278 1 0 decap_w0
xfeed_17277 1 0 decap_w0
xfeed_17276 1 0 decap_w0
xfeed_17275 1 0 decap_w0
xfeed_17274 1 0 decap_w0
xfeed_17273 1 0 decap_w0
xfeed_17272 1 0 decap_w0
xfeed_17271 1 0 decap_w0
xfeed_17270 1 0 decap_w0
xfeed_16749 1 0 decap_w0
xfeed_16748 1 0 decap_w0
xfeed_16747 1 0 decap_w0
xfeed_16746 1 0 decap_w0
xfeed_16745 1 0 decap_w0
xfeed_16744 1 0 decap_w0
xfeed_16743 1 0 decap_w0
xfeed_16742 1 0 decap_w0
xfeed_16741 1 0 decap_w0
xfeed_16740 1 0 decap_w0
xfeed_12439 1 0 decap_w0
xfeed_12438 1 0 decap_w0
xfeed_12437 1 0 decap_w0
xfeed_12436 1 0 decap_w0
xfeed_12435 1 0 decap_w0
xfeed_12434 1 0 decap_w0
xfeed_12433 1 0 decap_w0
xfeed_12432 1 0 decap_w0
xfeed_12431 1 0 decap_w0
xfeed_12430 1 0 decap_w0
xfeed_11909 1 0 decap_w0
xfeed_11908 1 0 decap_w0
xfeed_11907 1 0 decap_w0
xfeed_11906 1 0 decap_w0
xfeed_11905 1 0 decap_w0
xfeed_11904 1 0 decap_w0
xfeed_11903 1 0 decap_w0
xfeed_11902 1 0 decap_w0
xfeed_11901 1 0 decap_w0
xfeed_11900 1 0 decap_w0
xfeed_28204 1 0 decap_w0
xfeed_28203 1 0 tie
xfeed_28202 1 0 decap_w0
xfeed_28201 1 0 decap_w0
xfeed_28200 1 0 decap_w0
xfeed_6239 1 0 decap_w0
xfeed_6238 1 0 decap_w0
xfeed_6237 1 0 decap_w0
xfeed_6236 1 0 decap_w0
xfeed_6235 1 0 decap_w0
xfeed_6234 1 0 decap_w0
xfeed_6233 1 0 decap_w0
xfeed_6232 1 0 decap_w0
xfeed_6231 1 0 decap_w0
xfeed_6230 1 0 decap_w0
xfeed_5709 1 0 decap_w0
xfeed_5708 1 0 decap_w0
xfeed_5707 1 0 decap_w0
xfeed_5706 1 0 decap_w0
xfeed_5705 1 0 decap_w0
xfeed_5704 1 0 decap_w0
xfeed_5703 1 0 decap_w0
xfeed_5702 1 0 decap_w0
xfeed_5701 1 0 decap_w0
xfeed_5700 1 0 decap_w0
xfeed_28209 1 0 decap_w0
xfeed_28208 1 0 decap_w0
xfeed_28207 1 0 decap_w0
xfeed_28206 1 0 decap_w0
xfeed_28205 1 0 decap_w0
xfeed_27599 1 0 decap_w0
xfeed_27598 1 0 decap_w0
xfeed_27597 1 0 decap_w0
xfeed_27596 1 0 decap_w0
xfeed_27595 1 0 decap_w0
xfeed_27594 1 0 decap_w0
xfeed_27593 1 0 decap_w0
xfeed_27592 1 0 decap_w0
xfeed_27591 1 0 decap_w0
xfeed_27590 1 0 decap_w0
xfeed_23289 1 0 decap_w0
xfeed_23288 1 0 decap_w0
xfeed_23287 1 0 decap_w0
xfeed_23286 1 0 decap_w0
xfeed_23285 1 0 decap_w0
xfeed_23284 1 0 decap_w0
xfeed_23283 1 0 decap_w0
xfeed_23282 1 0 decap_w0
xfeed_23281 1 0 decap_w0
xfeed_23280 1 0 decap_w0
xfeed_22759 1 0 decap_w0
xfeed_22758 1 0 decap_w0
xfeed_22757 1 0 decap_w0
xfeed_22756 1 0 decap_w0
xfeed_22755 1 0 decap_w0
xfeed_22754 1 0 decap_w0
xfeed_22753 1 0 decap_w0
xfeed_22752 1 0 decap_w0
xfeed_22751 1 0 decap_w0
xfeed_22750 1 0 decap_w0
xfeed_17289 1 0 decap_w0
xfeed_17288 1 0 decap_w0
xfeed_17287 1 0 decap_w0
xfeed_17286 1 0 decap_w0
xfeed_17285 1 0 decap_w0
xfeed_17284 1 0 decap_w0
xfeed_17283 1 0 decap_w0
xfeed_17282 1 0 decap_w0
xfeed_17281 1 0 decap_w0
xfeed_17280 1 0 decap_w0
xfeed_16759 1 0 decap_w0
xfeed_16758 1 0 decap_w0
xfeed_16757 1 0 decap_w0
xfeed_16756 1 0 decap_w0
xfeed_16755 1 0 decap_w0
xfeed_16754 1 0 decap_w0
xfeed_16753 1 0 decap_w0
xfeed_16752 1 0 decap_w0
xfeed_16751 1 0 decap_w0
xfeed_16750 1 0 decap_w0
xfeed_12449 1 0 decap_w0
xfeed_12448 1 0 decap_w0
xfeed_12447 1 0 decap_w0
xfeed_12446 1 0 decap_w0
xfeed_12445 1 0 decap_w0
xfeed_12444 1 0 decap_w0
xfeed_12443 1 0 decap_w0
xfeed_12442 1 0 decap_w0
xfeed_12441 1 0 decap_w0
xfeed_12440 1 0 decap_w0
xfeed_11919 1 0 decap_w0
xfeed_11918 1 0 decap_w0
xfeed_11917 1 0 decap_w0
xfeed_11916 1 0 decap_w0
xfeed_11915 1 0 decap_w0
xfeed_11914 1 0 decap_w0
xfeed_11913 1 0 decap_w0
xfeed_11912 1 0 decap_w0
xfeed_11911 1 0 decap_w0
xfeed_11910 1 0 decap_w0
xfeed_28211 1 0 decap_w0
xfeed_28210 1 0 decap_w0
xfeed_6249 1 0 decap_w0
xfeed_6248 1 0 decap_w0
xfeed_6247 1 0 decap_w0
xfeed_6246 1 0 decap_w0
xfeed_6245 1 0 decap_w0
xfeed_6244 1 0 decap_w0
xfeed_6243 1 0 decap_w0
xfeed_6242 1 0 decap_w0
xfeed_6241 1 0 decap_w0
xfeed_6240 1 0 decap_w0
xfeed_5719 1 0 decap_w0
xfeed_5718 1 0 decap_w0
xfeed_5717 1 0 decap_w0
xfeed_5716 1 0 decap_w0
xfeed_5715 1 0 decap_w0
xfeed_5714 1 0 decap_w0
xfeed_5713 1 0 decap_w0
xfeed_5712 1 0 decap_w0
xfeed_5711 1 0 decap_w0
xfeed_5710 1 0 decap_w0
xfeed_1400 1 0 decap_w0
xfeed_1401 1 0 decap_w0
xfeed_1402 1 0 decap_w0
xfeed_1403 1 0 decap_w0
xfeed_1404 1 0 decap_w0
xfeed_1405 1 0 decap_w0
xfeed_1406 1 0 decap_w0
xfeed_1407 1 0 decap_w0
xfeed_1408 1 0 decap_w0
xfeed_1409 1 0 decap_w0
xfeed_28219 1 0 decap_w0
xfeed_28218 1 0 decap_w0
xfeed_28217 1 0 decap_w0
xfeed_28216 1 0 decap_w0
xfeed_28215 1 0 decap_w0
xfeed_28214 1 0 decap_w0
xfeed_28213 1 0 decap_w0
xfeed_28212 1 0 decap_w0
xfeed_23299 1 0 decap_w0
xfeed_23298 1 0 decap_w0
xfeed_23297 1 0 decap_w0
xfeed_23296 1 0 decap_w0
xfeed_23295 1 0 decap_w0
xfeed_23294 1 0 decap_w0
xfeed_23293 1 0 decap_w0
xfeed_23292 1 0 decap_w0
xfeed_23291 1 0 decap_w0
xfeed_23290 1 0 decap_w0
xfeed_22769 1 0 decap_w0
xfeed_22768 1 0 decap_w0
xfeed_22767 1 0 decap_w0
xfeed_22766 1 0 decap_w0
xfeed_22765 1 0 decap_w0
xfeed_22764 1 0 decap_w0
xfeed_22763 1 0 decap_w0
xfeed_22762 1 0 decap_w0
xfeed_22761 1 0 decap_w0
xfeed_22760 1 0 decap_w0
xfeed_17299 1 0 decap_w0
xfeed_17298 1 0 decap_w0
xfeed_17297 1 0 decap_w0
xfeed_17296 1 0 decap_w0
xfeed_17295 1 0 decap_w0
xfeed_17294 1 0 decap_w0
xfeed_17293 1 0 decap_w0
xfeed_17292 1 0 decap_w0
xfeed_17291 1 0 decap_w0
xfeed_17290 1 0 decap_w0
xfeed_16769 1 0 decap_w0
xfeed_16768 1 0 decap_w0
xfeed_16767 1 0 decap_w0
xfeed_16766 1 0 decap_w0
xfeed_16765 1 0 decap_w0
xfeed_16764 1 0 decap_w0
xfeed_16763 1 0 decap_w0
xfeed_16762 1 0 decap_w0
xfeed_16761 1 0 decap_w0
xfeed_16760 1 0 decap_w0
xfeed_12459 1 0 decap_w0
xfeed_12458 1 0 decap_w0
xfeed_12457 1 0 decap_w0
xfeed_12456 1 0 decap_w0
xfeed_12455 1 0 decap_w0
xfeed_12454 1 0 decap_w0
xfeed_12453 1 0 decap_w0
xfeed_12452 1 0 decap_w0
xfeed_12451 1 0 decap_w0
xfeed_12450 1 0 decap_w0
xfeed_11929 1 0 decap_w0
xfeed_11928 1 0 decap_w0
xfeed_11927 1 0 decap_w0
xfeed_11926 1 0 decap_w0
xfeed_11925 1 0 decap_w0
xfeed_11924 1 0 decap_w0
xfeed_11923 1 0 decap_w0
xfeed_11922 1 0 decap_w0
xfeed_11921 1 0 decap_w0
xfeed_11920 1 0 decap_w0
xfeed_6259 1 0 decap_w0
xfeed_6258 1 0 decap_w0
xfeed_6257 1 0 decap_w0
xfeed_6256 1 0 decap_w0
xfeed_6255 1 0 decap_w0
xfeed_6254 1 0 decap_w0
xfeed_6253 1 0 decap_w0
xfeed_6252 1 0 decap_w0
xfeed_6251 1 0 decap_w0
xfeed_6250 1 0 decap_w0
xfeed_5729 1 0 decap_w0
xfeed_5728 1 0 decap_w0
xfeed_5727 1 0 decap_w0
xfeed_5726 1 0 decap_w0
xfeed_5725 1 0 decap_w0
xfeed_5724 1 0 decap_w0
xfeed_5723 1 0 decap_w0
xfeed_5722 1 0 decap_w0
xfeed_5721 1 0 decap_w0
xfeed_5720 1 0 decap_w0
xsubckt_61_xor2_x0 1 0 37 59 168 xor2_x0
xfeed_1410 1 0 decap_w0
xfeed_1411 1 0 decap_w0
xfeed_1412 1 0 decap_w0
xfeed_1413 1 0 decap_w0
xfeed_1414 1 0 decap_w0
xfeed_1415 1 0 decap_w0
xfeed_1416 1 0 decap_w0
xfeed_1417 1 0 decap_w0
xfeed_1418 1 0 decap_w0
xfeed_1419 1 0 decap_w0
xfeed_28229 1 0 decap_w0
xfeed_28228 1 0 decap_w0
xfeed_28227 1 0 decap_w0
xfeed_28226 1 0 decap_w0
xfeed_28225 1 0 decap_w0
xfeed_28224 1 0 decap_w0
xfeed_28223 1 0 decap_w0
xfeed_28222 1 0 decap_w0
xfeed_28221 1 0 decap_w0
xfeed_28220 1 0 decap_w0
xfeed_22779 1 0 decap_w0
xfeed_22778 1 0 decap_w0
xfeed_22777 1 0 decap_w0
xfeed_22776 1 0 decap_w0
xfeed_22775 1 0 decap_w0
xfeed_22774 1 0 decap_w0
xfeed_22773 1 0 decap_w0
xfeed_22772 1 0 decap_w0
xfeed_22771 1 0 decap_w0
xfeed_22770 1 0 decap_w0
xfeed_16779 1 0 decap_w0
xfeed_16778 1 0 decap_w0
xfeed_16777 1 0 decap_w0
xfeed_16776 1 0 decap_w0
xfeed_16775 1 0 decap_w0
xfeed_16774 1 0 decap_w0
xfeed_16773 1 0 decap_w0
xfeed_16772 1 0 decap_w0
xfeed_16771 1 0 decap_w0
xfeed_16770 1 0 decap_w0
xfeed_12469 1 0 decap_w0
xfeed_12468 1 0 decap_w0
xfeed_12467 1 0 decap_w0
xfeed_12466 1 0 decap_w0
xfeed_12465 1 0 decap_w0
xfeed_12464 1 0 decap_w0
xfeed_12463 1 0 decap_w0
xfeed_12462 1 0 decap_w0
xfeed_12461 1 0 decap_w0
xfeed_12460 1 0 decap_w0
xfeed_11939 1 0 decap_w0
xfeed_11938 1 0 decap_w0
xfeed_11937 1 0 decap_w0
xfeed_11936 1 0 decap_w0
xfeed_11935 1 0 decap_w0
xfeed_11934 1 0 decap_w0
xfeed_11933 1 0 decap_w0
xfeed_11932 1 0 decap_w0
xfeed_11931 1 0 decap_w0
xfeed_11930 1 0 decap_w0
xfeed_6269 1 0 decap_w0
xfeed_6268 1 0 decap_w0
xfeed_6267 1 0 decap_w0
xfeed_6266 1 0 decap_w0
xfeed_6265 1 0 decap_w0
xfeed_6264 1 0 decap_w0
xfeed_6263 1 0 decap_w0
xfeed_6262 1 0 decap_w0
xfeed_6261 1 0 decap_w0
xfeed_6260 1 0 decap_w0
xfeed_5739 1 0 decap_w0
xfeed_5738 1 0 decap_w0
xfeed_5737 1 0 decap_w0
xfeed_5736 1 0 decap_w0
xfeed_5735 1 0 decap_w0
xfeed_5734 1 0 decap_w0
xfeed_5733 1 0 decap_w0
xfeed_5732 1 0 decap_w0
xfeed_5731 1 0 decap_w0
xfeed_5730 1 0 decap_w0
xfeed_1420 1 0 decap_w0
xfeed_1421 1 0 decap_w0
xfeed_1422 1 0 decap_w0
xfeed_1423 1 0 decap_w0
xfeed_1424 1 0 decap_w0
xfeed_1425 1 0 decap_w0
xfeed_1426 1 0 decap_w0
xfeed_1427 1 0 decap_w0
xfeed_1428 1 0 decap_w0
xfeed_1429 1 0 decap_w0
xfeed_28239 1 0 decap_w0
xfeed_28238 1 0 decap_w0
xfeed_28237 1 0 decap_w0
xfeed_28236 1 0 decap_w0
xfeed_28235 1 0 decap_w0
xfeed_28234 1 0 decap_w0
xfeed_28233 1 0 decap_w0
xfeed_28232 1 0 decap_w0
xfeed_28231 1 0 decap_w0
xfeed_28230 1 0 decap_w0
xfeed_27709 1 0 decap_w0
xfeed_27708 1 0 decap_w0
xfeed_27707 1 0 decap_w0
xfeed_27706 1 0 decap_w0
xfeed_27705 1 0 decap_w0
xfeed_27704 1 0 decap_w0
xfeed_27703 1 0 decap_w0
xfeed_27702 1 0 decap_w0
xfeed_27701 1 0 decap_w0
xfeed_27700 1 0 decap_w0
xfeed_22789 1 0 decap_w0
xfeed_22788 1 0 decap_w0
xfeed_22787 1 0 decap_w0
xfeed_22786 1 0 decap_w0
xfeed_22785 1 0 decap_w0
xfeed_22784 1 0 decap_w0
xfeed_22783 1 0 decap_w0
xfeed_22782 1 0 decap_w0
xfeed_22781 1 0 decap_w0
xfeed_22780 1 0 decap_w0
xfeed_16786 1 0 decap_w0
xfeed_16785 1 0 decap_w0
xfeed_16784 1 0 decap_w0
xfeed_16783 1 0 decap_w0
xfeed_16782 1 0 decap_w0
xfeed_16781 1 0 decap_w0
xfeed_16780 1 0 decap_w0
xfeed_12479 1 0 decap_w0
xfeed_12478 1 0 decap_w0
xfeed_12477 1 0 decap_w0
xfeed_12476 1 0 decap_w0
xfeed_12475 1 0 decap_w0
xfeed_12474 1 0 decap_w0
xfeed_12473 1 0 decap_w0
xfeed_12472 1 0 decap_w0
xfeed_12471 1 0 decap_w0
xfeed_12470 1 0 decap_w0
xfeed_11947 1 0 decap_w0
xfeed_11946 1 0 decap_w0
xfeed_11945 1 0 decap_w0
xfeed_11944 1 0 decap_w0
xfeed_11943 1 0 decap_w0
xfeed_11942 1 0 decap_w0
xfeed_11941 1 0 decap_w0
xfeed_11940 1 0 decap_w0
xfeed_16789 1 0 decap_w0
xfeed_16788 1 0 decap_w0
xfeed_16787 1 0 decap_w0
xfeed_11949 1 0 decap_w0
xfeed_11948 1 0 decap_w0
xfeed_6279 1 0 decap_w0
xfeed_6278 1 0 decap_w0
xfeed_6277 1 0 decap_w0
xfeed_6276 1 0 decap_w0
xfeed_6275 1 0 decap_w0
xfeed_6274 1 0 decap_w0
xfeed_6273 1 0 decap_w0
xfeed_6272 1 0 decap_w0
xfeed_6271 1 0 decap_w0
xfeed_6270 1 0 decap_w0
xfeed_5749 1 0 decap_w0
xfeed_5748 1 0 decap_w0
xfeed_5747 1 0 decap_w0
xfeed_5746 1 0 decap_w0
xfeed_5745 1 0 decap_w0
xfeed_5744 1 0 decap_w0
xfeed_5743 1 0 decap_w0
xfeed_5742 1 0 decap_w0
xfeed_5741 1 0 decap_w0
xfeed_5740 1 0 decap_w0
xfeed_1430 1 0 decap_w0
xfeed_1431 1 0 decap_w0
xfeed_1432 1 0 decap_w0
xfeed_1433 1 0 decap_w0
xfeed_1434 1 0 decap_w0
xfeed_1435 1 0 decap_w0
xfeed_1436 1 0 decap_w0
xfeed_1437 1 0 decap_w0
xfeed_1438 1 0 decap_w0
xfeed_1439 1 0 decap_w0
xfeed_28249 1 0 decap_w0
xfeed_28248 1 0 decap_w0
xfeed_28247 1 0 decap_w0
xfeed_28246 1 0 decap_w0
xfeed_28245 1 0 decap_w0
xfeed_28244 1 0 decap_w0
xfeed_28243 1 0 decap_w0
xfeed_28242 1 0 decap_w0
xfeed_28241 1 0 decap_w0
xfeed_28240 1 0 decap_w0
xfeed_27719 1 0 decap_w0
xfeed_27718 1 0 decap_w0
xfeed_27717 1 0 decap_w0
xfeed_27716 1 0 decap_w0
xfeed_27715 1 0 decap_w0
xfeed_27714 1 0 decap_w0
xfeed_27713 1 0 decap_w0
xfeed_27712 1 0 decap_w0
xfeed_27711 1 0 decap_w0
xfeed_27710 1 0 decap_w0
xfeed_23409 1 0 decap_w0
xfeed_23408 1 0 decap_w0
xfeed_23407 1 0 decap_w0
xfeed_23406 1 0 decap_w0
xfeed_23405 1 0 decap_w0
xfeed_23404 1 0 decap_w0
xfeed_23403 1 0 decap_w0
xfeed_23402 1 0 decap_w0
xfeed_23401 1 0 decap_w0
xfeed_23400 1 0 decap_w0
xfeed_22799 1 0 decap_w0
xfeed_22798 1 0 decap_w0
xfeed_22797 1 0 decap_w0
xfeed_22796 1 0 decap_w0
xfeed_22795 1 0 decap_w0
xfeed_22794 1 0 decap_w0
xfeed_22793 1 0 decap_w0
xfeed_22792 1 0 decap_w0
xfeed_22791 1 0 decap_w0
xfeed_22790 1 0 decap_w0
xfeed_17409 1 0 decap_w0
xfeed_17408 1 0 decap_w0
xfeed_17407 1 0 decap_w0
xfeed_17406 1 0 decap_w0
xfeed_17405 1 0 decap_w0
xfeed_17404 1 0 decap_w0
xfeed_17403 1 0 decap_w0
xfeed_17402 1 0 decap_w0
xfeed_17401 1 0 decap_w0
xfeed_17400 1 0 decap_w0
xfeed_16793 1 0 decap_w0
xfeed_16792 1 0 decap_w0
xfeed_16791 1 0 decap_w0
xfeed_16790 1 0 decap_w0
xfeed_12489 1 0 decap_w0
xfeed_12488 1 0 decap_w0
xfeed_12487 1 0 decap_w0
xfeed_12486 1 0 tie
xfeed_12485 1 0 decap_w0
xfeed_12484 1 0 decap_w0
xfeed_12483 1 0 decap_w0
xfeed_12482 1 0 decap_w0
xfeed_12481 1 0 decap_w0
xfeed_12480 1 0 decap_w0
xfeed_11954 1 0 decap_w0
xfeed_11953 1 0 decap_w0
xfeed_11952 1 0 decap_w0
xfeed_11951 1 0 decap_w0
xfeed_11950 1 0 decap_w0
xfeed_16799 1 0 decap_w0
xfeed_16798 1 0 decap_w0
xfeed_16797 1 0 decap_w0
xfeed_16796 1 0 decap_w0
xfeed_16795 1 0 decap_w0
xfeed_16794 1 0 decap_w0
xfeed_11959 1 0 decap_w0
xfeed_11958 1 0 decap_w0
xfeed_11957 1 0 decap_w0
xfeed_11956 1 0 decap_w0
xfeed_11955 1 0 decap_w0
xfeed_6289 1 0 decap_w0
xfeed_6288 1 0 decap_w0
xfeed_6287 1 0 decap_w0
xfeed_6286 1 0 decap_w0
xfeed_6285 1 0 decap_w0
xfeed_6284 1 0 decap_w0
xfeed_6283 1 0 decap_w0
xfeed_6282 1 0 decap_w0
xfeed_6281 1 0 decap_w0
xfeed_6280 1 0 decap_w0
xfeed_5759 1 0 decap_w0
xfeed_5758 1 0 decap_w0
xfeed_5757 1 0 decap_w0
xfeed_5756 1 0 decap_w0
xfeed_5755 1 0 decap_w0
xfeed_5754 1 0 decap_w0
xfeed_5753 1 0 decap_w0
xfeed_5752 1 0 decap_w0
xfeed_5751 1 0 decap_w0
xfeed_5750 1 0 decap_w0
xfeed_1440 1 0 decap_w0
xfeed_1441 1 0 decap_w0
xfeed_1442 1 0 decap_w0
xfeed_1443 1 0 decap_w0
xfeed_1444 1 0 decap_w0
xfeed_1445 1 0 decap_w0
xfeed_1446 1 0 decap_w0
xfeed_1447 1 0 decap_w0
xfeed_1448 1 0 decap_w0
xfeed_1449 1 0 decap_w0
xfeed_28259 1 0 decap_w0
xfeed_28258 1 0 decap_w0
xfeed_28257 1 0 decap_w0
xfeed_28256 1 0 decap_w0
xfeed_28255 1 0 decap_w0
xfeed_28254 1 0 decap_w0
xfeed_28253 1 0 decap_w0
xfeed_28252 1 0 decap_w0
xfeed_28251 1 0 decap_w0
xfeed_28250 1 0 decap_w0
xfeed_27729 1 0 decap_w0
xfeed_27728 1 0 decap_w0
xfeed_27727 1 0 decap_w0
xfeed_27726 1 0 decap_w0
xfeed_27725 1 0 decap_w0
xfeed_27724 1 0 decap_w0
xfeed_27723 1 0 decap_w0
xfeed_27722 1 0 decap_w0
xfeed_27721 1 0 decap_w0
xfeed_27720 1 0 decap_w0
xfeed_23419 1 0 decap_w0
xfeed_23418 1 0 decap_w0
xfeed_23417 1 0 decap_w0
xfeed_23416 1 0 decap_w0
xfeed_23415 1 0 decap_w0
xfeed_23414 1 0 decap_w0
xfeed_23413 1 0 decap_w0
xfeed_23412 1 0 decap_w0
xfeed_23411 1 0 decap_w0
xfeed_23410 1 0 decap_w0
xfeed_17419 1 0 decap_w0
xfeed_17418 1 0 decap_w0
xfeed_17417 1 0 decap_w0
xfeed_17416 1 0 decap_w0
xfeed_17415 1 0 decap_w0
xfeed_17414 1 0 decap_w0
xfeed_17413 1 0 decap_w0
xfeed_17412 1 0 decap_w0
xfeed_17411 1 0 decap_w0
xfeed_17410 1 0 decap_w0
xfeed_13109 1 0 decap_w0
xfeed_13108 1 0 decap_w0
xfeed_13107 1 0 decap_w0
xfeed_13106 1 0 decap_w0
xfeed_13105 1 0 decap_w0
xfeed_13104 1 0 decap_w0
xfeed_13103 1 0 decap_w0
xfeed_13102 1 0 decap_w0
xfeed_13101 1 0 decap_w0
xfeed_13100 1 0 decap_w0
xfeed_12499 1 0 decap_w0
xfeed_12498 1 0 decap_w0
xfeed_12497 1 0 decap_w0
xfeed_12496 1 0 decap_w0
xfeed_12495 1 0 decap_w0
xfeed_12494 1 0 decap_w0
xfeed_12493 1 0 decap_w0
xfeed_12492 1 0 decap_w0
xfeed_12491 1 0 decap_w0
xfeed_12490 1 0 decap_w0
xfeed_11961 1 0 decap_w0
xfeed_11960 1 0 decap_w0
xfeed_11969 1 0 decap_w0
xfeed_11968 1 0 decap_w0
xfeed_11967 1 0 decap_w0
xfeed_11966 1 0 decap_w0
xfeed_11965 1 0 decap_w0
xfeed_11964 1 0 decap_w0
xfeed_11963 1 0 decap_w0
xfeed_11962 1 0 decap_w0
xfeed_6299 1 0 decap_w0
xfeed_6298 1 0 decap_w0
xfeed_6297 1 0 decap_w0
xfeed_6296 1 0 decap_w0
xfeed_6295 1 0 decap_w0
xfeed_6294 1 0 decap_w0
xfeed_6293 1 0 decap_w0
xfeed_6292 1 0 decap_w0
xfeed_6291 1 0 decap_w0
xfeed_6290 1 0 decap_w0
xfeed_5769 1 0 decap_w0
xfeed_5768 1 0 decap_w0
xfeed_5767 1 0 decap_w0
xfeed_5766 1 0 decap_w0
xfeed_5765 1 0 decap_w0
xfeed_5764 1 0 decap_w0
xfeed_5763 1 0 decap_w0
xfeed_5762 1 0 decap_w0
xfeed_5761 1 0 decap_w0
xfeed_5760 1 0 decap_w0
xfeed_1450 1 0 decap_w0
xfeed_1451 1 0 decap_w0
xfeed_1452 1 0 decap_w0
xfeed_1453 1 0 decap_w0
xfeed_1454 1 0 decap_w0
xfeed_1455 1 0 decap_w0
xfeed_1456 1 0 decap_w0
xfeed_1457 1 0 decap_w0
xfeed_1458 1 0 decap_w0
xfeed_1459 1 0 decap_w0
xfeed_28269 1 0 decap_w0
xfeed_28268 1 0 decap_w0
xfeed_28267 1 0 decap_w0
xfeed_28266 1 0 decap_w0
xfeed_28265 1 0 decap_w0
xfeed_28264 1 0 decap_w0
xfeed_28263 1 0 decap_w0
xfeed_28262 1 0 decap_w0
xfeed_28261 1 0 decap_w0
xfeed_28260 1 0 decap_w0
xfeed_27739 1 0 decap_w0
xfeed_27738 1 0 decap_w0
xfeed_27737 1 0 decap_w0
xfeed_27736 1 0 decap_w0
xfeed_27735 1 0 decap_w0
xfeed_27734 1 0 decap_w0
xfeed_27733 1 0 decap_w0
xfeed_27732 1 0 decap_w0
xfeed_27731 1 0 decap_w0
xfeed_27730 1 0 decap_w0
xfeed_23429 1 0 decap_w0
xfeed_23428 1 0 decap_w0
xfeed_23427 1 0 decap_w0
xfeed_23426 1 0 decap_w0
xfeed_23425 1 0 decap_w0
xfeed_23424 1 0 decap_w0
xfeed_23423 1 0 decap_w0
xfeed_23422 1 0 decap_w0
xfeed_23421 1 0 decap_w0
xfeed_23420 1 0 decap_w0
xfeed_17429 1 0 decap_w0
xfeed_17428 1 0 decap_w0
xfeed_17427 1 0 decap_w0
xfeed_17426 1 0 decap_w0
xfeed_17425 1 0 decap_w0
xfeed_17424 1 0 decap_w0
xfeed_17423 1 0 decap_w0
xfeed_17422 1 0 decap_w0
xfeed_17421 1 0 decap_w0
xfeed_17420 1 0 decap_w0
xfeed_13119 1 0 decap_w0
xfeed_13118 1 0 decap_w0
xfeed_13117 1 0 decap_w0
xfeed_13116 1 0 decap_w0
xfeed_13115 1 0 decap_w0
xfeed_13114 1 0 decap_w0
xfeed_13113 1 0 decap_w0
xfeed_13112 1 0 decap_w0
xfeed_13111 1 0 decap_w0
xfeed_13110 1 0 decap_w0
xfeed_11979 1 0 decap_w0
xfeed_11978 1 0 decap_w0
xfeed_11977 1 0 decap_w0
xfeed_11976 1 0 decap_w0
xfeed_11975 1 0 decap_w0
xfeed_11974 1 0 decap_w0
xfeed_11973 1 0 decap_w0
xfeed_11972 1 0 decap_w0
xfeed_11971 1 0 decap_w0
xfeed_11970 1 0 decap_w0
xfeed_5779 1 0 decap_w0
xfeed_5778 1 0 decap_w0
xfeed_5777 1 0 decap_w0
xfeed_5776 1 0 decap_w0
xfeed_5775 1 0 decap_w0
xfeed_5774 1 0 decap_w0
xfeed_5773 1 0 decap_w0
xfeed_5772 1 0 decap_w0
xfeed_5771 1 0 decap_w0
xfeed_5770 1 0 decap_w0
xfeed_1460 1 0 decap_w0
xfeed_1461 1 0 decap_w0
xfeed_1462 1 0 decap_w0
xfeed_1463 1 0 decap_w0
xfeed_1464 1 0 decap_w0
xfeed_1465 1 0 decap_w0
xfeed_1466 1 0 decap_w0
xfeed_1467 1 0 decap_w0
xfeed_1468 1 0 decap_w0
xfeed_1469 1 0 decap_w0
xfeed_28279 1 0 decap_w0
xfeed_28278 1 0 decap_w0
xfeed_28277 1 0 decap_w0
xfeed_28276 1 0 decap_w0
xfeed_28275 1 0 decap_w0
xfeed_28274 1 0 decap_w0
xfeed_28273 1 0 decap_w0
xfeed_28272 1 0 decap_w0
xfeed_28271 1 0 decap_w0
xfeed_28270 1 0 decap_w0
xfeed_27749 1 0 decap_w0
xfeed_27748 1 0 decap_w0
xfeed_27747 1 0 decap_w0
xfeed_27746 1 0 decap_w0
xfeed_27745 1 0 decap_w0
xfeed_27744 1 0 decap_w0
xfeed_27743 1 0 decap_w0
xfeed_27742 1 0 decap_w0
xfeed_27741 1 0 decap_w0
xfeed_27740 1 0 decap_w0
xfeed_23439 1 0 decap_w0
xfeed_23438 1 0 decap_w0
xfeed_23437 1 0 decap_w0
xfeed_23436 1 0 decap_w0
xfeed_23435 1 0 decap_w0
xfeed_23434 1 0 decap_w0
xfeed_23433 1 0 decap_w0
xfeed_23432 1 0 decap_w0
xfeed_23431 1 0 decap_w0
xfeed_23430 1 0 decap_w0
xfeed_22909 1 0 decap_w0
xfeed_22908 1 0 decap_w0
xfeed_22907 1 0 decap_w0
xfeed_22906 1 0 decap_w0
xfeed_22905 1 0 decap_w0
xfeed_22904 1 0 decap_w0
xfeed_22903 1 0 decap_w0
xfeed_22902 1 0 decap_w0
xfeed_22901 1 0 decap_w0
xfeed_22900 1 0 decap_w0
xfeed_17439 1 0 decap_w0
xfeed_17438 1 0 decap_w0
xfeed_17437 1 0 decap_w0
xfeed_17436 1 0 decap_w0
xfeed_17435 1 0 decap_w0
xfeed_17434 1 0 decap_w0
xfeed_17433 1 0 decap_w0
xfeed_17432 1 0 decap_w0
xfeed_17431 1 0 decap_w0
xfeed_17430 1 0 decap_w0
xfeed_16909 1 0 decap_w0
xfeed_16908 1 0 decap_w0
xfeed_16907 1 0 decap_w0
xfeed_16906 1 0 decap_w0
xfeed_16905 1 0 decap_w0
xfeed_16904 1 0 decap_w0
xfeed_16903 1 0 decap_w0
xfeed_16902 1 0 decap_w0
xfeed_16901 1 0 decap_w0
xfeed_16900 1 0 decap_w0
xfeed_13129 1 0 tie
xfeed_13128 1 0 decap_w0
xfeed_13127 1 0 decap_w0
xfeed_13126 1 0 decap_w0
xfeed_13125 1 0 decap_w0
xfeed_13124 1 0 decap_w0
xfeed_13123 1 0 decap_w0
xfeed_13122 1 0 decap_w0
xfeed_13121 1 0 decap_w0
xfeed_13120 1 0 decap_w0
xsubckt_60_nexor2_x0 1 0 169 123 30 nexor2_x0
xfeed_11989 1 0 decap_w0
xfeed_11988 1 0 decap_w0
xfeed_11987 1 0 decap_w0
xfeed_11986 1 0 decap_w0
xfeed_11985 1 0 decap_w0
xfeed_11984 1 0 decap_w0
xfeed_11983 1 0 decap_w0
xfeed_11982 1 0 decap_w0
xfeed_11981 1 0 decap_w0
xfeed_11980 1 0 decap_w0
xfeed_5789 1 0 decap_w0
xfeed_5788 1 0 decap_w0
xfeed_5787 1 0 decap_w0
xfeed_5786 1 0 decap_w0
xfeed_5785 1 0 decap_w0
xfeed_5784 1 0 decap_w0
xfeed_5783 1 0 decap_w0
xfeed_5782 1 0 decap_w0
xfeed_5781 1 0 decap_w0
xfeed_5780 1 0 decap_w0
xsubckt_42_nexor2_x0 1 0 181 121 180 nexor2_x0
xfeed_1470 1 0 decap_w0
xfeed_1471 1 0 decap_w0
xfeed_1472 1 0 decap_w0
xfeed_1473 1 0 decap_w0
xfeed_1474 1 0 decap_w0
xfeed_1475 1 0 decap_w0
xfeed_1476 1 0 decap_w0
xfeed_1477 1 0 decap_w0
xfeed_1478 1 0 decap_w0
xfeed_1479 1 0 decap_w0
xfeed_28289 1 0 decap_w0
xfeed_28288 1 0 decap_w0
xfeed_28287 1 0 decap_w0
xfeed_28286 1 0 decap_w0
xfeed_28285 1 0 decap_w0
xfeed_28284 1 0 decap_w0
xfeed_28283 1 0 decap_w0
xfeed_28282 1 0 decap_w0
xfeed_28281 1 0 decap_w0
xfeed_28280 1 0 decap_w0
xfeed_27759 1 0 decap_w0
xfeed_27758 1 0 decap_w0
xfeed_27757 1 0 decap_w0
xfeed_27756 1 0 decap_w0
xfeed_27755 1 0 decap_w0
xfeed_27754 1 0 decap_w0
xfeed_27753 1 0 decap_w0
xfeed_27752 1 0 decap_w0
xfeed_27751 1 0 decap_w0
xfeed_27750 1 0 decap_w0
xfeed_23449 1 0 decap_w0
xfeed_23448 1 0 decap_w0
xfeed_23447 1 0 decap_w0
xfeed_23446 1 0 decap_w0
xfeed_23445 1 0 decap_w0
xfeed_23444 1 0 decap_w0
xfeed_23443 1 0 decap_w0
xfeed_23442 1 0 decap_w0
xfeed_23441 1 0 decap_w0
xfeed_23440 1 0 decap_w0
xfeed_22919 1 0 decap_w0
xfeed_22918 1 0 decap_w0
xfeed_22917 1 0 decap_w0
xfeed_22916 1 0 decap_w0
xfeed_22915 1 0 decap_w0
xfeed_22914 1 0 decap_w0
xfeed_22913 1 0 decap_w0
xfeed_22912 1 0 decap_w0
xfeed_22911 1 0 decap_w0
xfeed_22910 1 0 decap_w0
xfeed_17449 1 0 decap_w0
xfeed_17448 1 0 decap_w0
xfeed_17447 1 0 decap_w0
xfeed_17446 1 0 decap_w0
xfeed_17445 1 0 decap_w0
xfeed_17444 1 0 decap_w0
xfeed_17443 1 0 decap_w0
xfeed_17442 1 0 decap_w0
xfeed_17441 1 0 decap_w0
xfeed_17440 1 0 decap_w0
xfeed_16919 1 0 decap_w0
xfeed_16918 1 0 decap_w0
xfeed_16917 1 0 decap_w0
xfeed_16916 1 0 decap_w0
xfeed_16915 1 0 decap_w0
xfeed_16914 1 0 decap_w0
xfeed_16913 1 0 decap_w0
xfeed_16912 1 0 decap_w0
xfeed_16911 1 0 decap_w0
xfeed_16910 1 0 decap_w0
xfeed_13139 1 0 decap_w0
xfeed_13138 1 0 decap_w0
xfeed_13137 1 0 decap_w0
xfeed_13136 1 0 decap_w0
xfeed_13135 1 0 decap_w0
xfeed_13134 1 0 decap_w0
xfeed_13133 1 0 decap_w0
xfeed_13132 1 0 decap_w0
xfeed_13131 1 0 decap_w0
xfeed_13130 1 0 decap_w0
xfeed_12609 1 0 decap_w0
xfeed_12608 1 0 decap_w0
xfeed_12607 1 0 decap_w0
xfeed_12606 1 0 decap_w0
xfeed_12605 1 0 decap_w0
xfeed_12604 1 0 decap_w0
xfeed_12603 1 0 decap_w0
xfeed_12602 1 0 decap_w0
xfeed_12601 1 0 decap_w0
xfeed_12600 1 0 decap_w0
xfeed_11999 1 0 decap_w0
xfeed_11998 1 0 decap_w0
xfeed_11997 1 0 decap_w0
xfeed_11996 1 0 decap_w0
xfeed_11995 1 0 decap_w0
xfeed_11994 1 0 decap_w0
xfeed_11993 1 0 decap_w0
xfeed_11992 1 0 decap_w0
xfeed_11991 1 0 decap_w0
xfeed_11990 1 0 decap_w0
xfeed_6409 1 0 decap_w0
xfeed_6408 1 0 decap_w0
xfeed_6407 1 0 decap_w0
xfeed_6406 1 0 decap_w0
xfeed_6405 1 0 decap_w0
xfeed_6404 1 0 decap_w0
xfeed_6403 1 0 decap_w0
xfeed_6402 1 0 decap_w0
xfeed_6401 1 0 decap_w0
xfeed_6400 1 0 decap_w0
xfeed_5799 1 0 decap_w0
xfeed_5798 1 0 decap_w0
xfeed_5797 1 0 decap_w0
xfeed_5796 1 0 decap_w0
xfeed_5795 1 0 decap_w0
xfeed_5794 1 0 decap_w0
xfeed_5793 1 0 decap_w0
xfeed_5792 1 0 decap_w0
xfeed_5791 1 0 decap_w0
xfeed_5790 1 0 decap_w0
xsubckt_15_nexor2_x0 1 0 130 132 129 nexor2_x0
xsubckt_24_nexor2_x0 1 0 125 138 123 nexor2_x0
xfeed_1480 1 0 decap_w0
xfeed_1481 1 0 decap_w0
xfeed_1482 1 0 decap_w0
xfeed_1483 1 0 decap_w0
xfeed_1484 1 0 decap_w0
xfeed_1485 1 0 decap_w0
xfeed_1486 1 0 decap_w0
xfeed_1487 1 0 decap_w0
xfeed_1488 1 0 decap_w0
xfeed_1489 1 0 decap_w0
xfeed_28299 1 0 decap_w0
xfeed_28298 1 0 decap_w0
xfeed_28297 1 0 decap_w0
xfeed_28296 1 0 decap_w0
xfeed_28295 1 0 decap_w0
xfeed_28294 1 0 decap_w0
xfeed_28293 1 0 decap_w0
xfeed_28292 1 0 decap_w0
xfeed_28291 1 0 decap_w0
xfeed_28290 1 0 decap_w0
xfeed_27769 1 0 decap_w0
xfeed_27768 1 0 decap_w0
xfeed_27767 1 0 decap_w0
xfeed_27766 1 0 decap_w0
xfeed_27765 1 0 decap_w0
xfeed_27764 1 0 decap_w0
xfeed_27763 1 0 decap_w0
xfeed_27762 1 0 decap_w0
xfeed_27761 1 0 decap_w0
xfeed_27760 1 0 decap_w0
xfeed_23459 1 0 decap_w0
xfeed_23458 1 0 decap_w0
xfeed_23457 1 0 decap_w0
xfeed_23456 1 0 decap_w0
xfeed_23455 1 0 decap_w0
xfeed_23454 1 0 decap_w0
xfeed_23453 1 0 decap_w0
xfeed_23452 1 0 decap_w0
xfeed_23451 1 0 decap_w0
xfeed_23450 1 0 decap_w0
xfeed_22929 1 0 decap_w0
xfeed_22928 1 0 decap_w0
xfeed_22927 1 0 decap_w0
xfeed_22926 1 0 decap_w0
xfeed_22925 1 0 decap_w0
xfeed_22924 1 0 decap_w0
xfeed_22923 1 0 decap_w0
xfeed_22922 1 0 decap_w0
xfeed_22921 1 0 decap_w0
xfeed_22920 1 0 decap_w0
xfeed_17459 1 0 decap_w0
xfeed_17458 1 0 decap_w0
xfeed_17457 1 0 decap_w0
xfeed_17456 1 0 decap_w0
xfeed_17455 1 0 decap_w0
xfeed_17454 1 0 decap_w0
xfeed_17453 1 0 decap_w0
xfeed_17452 1 0 decap_w0
xfeed_17451 1 0 decap_w0
xfeed_17450 1 0 decap_w0
xfeed_16926 1 0 decap_w0
xfeed_16925 1 0 decap_w0
xfeed_16924 1 0 decap_w0
xfeed_16923 1 0 decap_w0
xfeed_16922 1 0 decap_w0
xfeed_16921 1 0 decap_w0
xfeed_16920 1 0 decap_w0
xfeed_13149 1 0 decap_w0
xfeed_13148 1 0 decap_w0
xfeed_13147 1 0 decap_w0
xfeed_13146 1 0 decap_w0
xfeed_13145 1 0 decap_w0
xfeed_13144 1 0 decap_w0
xfeed_13143 1 0 decap_w0
xfeed_13142 1 0 decap_w0
xfeed_13141 1 0 decap_w0
xfeed_13140 1 0 decap_w0
xfeed_12619 1 0 decap_w0
xfeed_12618 1 0 decap_w0
xfeed_12617 1 0 decap_w0
xfeed_12616 1 0 decap_w0
xfeed_12615 1 0 decap_w0
xfeed_12614 1 0 decap_w0
xfeed_12613 1 0 decap_w0
xfeed_12612 1 0 decap_w0
xfeed_12611 1 0 decap_w0
xfeed_12610 1 0 decap_w0
xfeed_16929 1 0 decap_w0
xfeed_16928 1 0 decap_w0
xfeed_16927 1 0 decap_w0
xfeed_6419 1 0 decap_w0
xfeed_6418 1 0 decap_w0
xfeed_6417 1 0 decap_w0
xfeed_6416 1 0 decap_w0
xfeed_6415 1 0 decap_w0
xfeed_6414 1 0 decap_w0
xfeed_6413 1 0 decap_w0
xfeed_6412 1 0 decap_w0
xfeed_6411 1 0 decap_w0
xfeed_6410 1 0 decap_w0
xsubckt_93_nexor2_x0 1 0 145 157 144 nexor2_x0
xfeed_1490 1 0 decap_w0
xfeed_1491 1 0 decap_w0
xfeed_1492 1 0 decap_w0
xfeed_1493 1 0 decap_w0
xfeed_1494 1 0 decap_w0
xfeed_1495 1 0 decap_w0
xfeed_1496 1 0 decap_w0
xfeed_1497 1 0 decap_w0
xfeed_1498 1 0 decap_w0
xfeed_1499 1 0 decap_w0
xfeed_2100 1 0 decap_w0
xfeed_2101 1 0 decap_w0
xfeed_2102 1 0 decap_w0
xfeed_2103 1 0 decap_w0
xfeed_2104 1 0 decap_w0
xfeed_2105 1 0 decap_w0
xfeed_2106 1 0 decap_w0
xfeed_2107 1 0 decap_w0
xfeed_2108 1 0 decap_w0
xfeed_2109 1 0 decap_w0
xfeed_27779 1 0 decap_w0
xfeed_27778 1 0 decap_w0
xfeed_27777 1 0 decap_w0
xfeed_27776 1 0 decap_w0
xfeed_27775 1 0 decap_w0
xfeed_27774 1 0 decap_w0
xfeed_27773 1 0 decap_w0
xfeed_27772 1 0 decap_w0
xfeed_27771 1 0 decap_w0
xfeed_27770 1 0 decap_w0
xfeed_23469 1 0 decap_w0
xfeed_23468 1 0 decap_w0
xfeed_23467 1 0 decap_w0
xfeed_23466 1 0 decap_w0
xfeed_23465 1 0 decap_w0
xfeed_23464 1 0 decap_w0
xfeed_23463 1 0 decap_w0
xfeed_23462 1 0 decap_w0
xfeed_23461 1 0 decap_w0
xfeed_23460 1 0 decap_w0
xfeed_22939 1 0 decap_w0
xfeed_22938 1 0 decap_w0
xfeed_22937 1 0 decap_w0
xfeed_22936 1 0 decap_w0
xfeed_22935 1 0 decap_w0
xfeed_22934 1 0 decap_w0
xfeed_22933 1 0 decap_w0
xfeed_22932 1 0 decap_w0
xfeed_22931 1 0 decap_w0
xfeed_22930 1 0 decap_w0
xfeed_17469 1 0 decap_w0
xfeed_17468 1 0 decap_w0
xfeed_17467 1 0 decap_w0
xfeed_17466 1 0 decap_w0
xfeed_17464 1 0 decap_w0
xfeed_17463 1 0 decap_w0
xfeed_17462 1 0 decap_w0
xfeed_17461 1 0 decap_w0
xfeed_17460 1 0 decap_w0
xfeed_16933 1 0 decap_w0
xfeed_16932 1 0 decap_w0
xfeed_16931 1 0 decap_w0
xfeed_16930 1 0 decap_w0
xfeed_13159 1 0 decap_w0
xfeed_13158 1 0 decap_w0
xfeed_13157 1 0 decap_w0
xfeed_13156 1 0 decap_w0
xfeed_13155 1 0 decap_w0
xfeed_13154 1 0 decap_w0
xfeed_13153 1 0 decap_w0
xfeed_13152 1 0 decap_w0
xfeed_13151 1 0 decap_w0
xfeed_13150 1 0 decap_w0
xfeed_12629 1 0 decap_w0
xfeed_12628 1 0 decap_w0
xfeed_12627 1 0 decap_w0
xfeed_12626 1 0 decap_w0
xfeed_12625 1 0 decap_w0
xfeed_12624 1 0 decap_w0
xfeed_12623 1 0 decap_w0
xfeed_12622 1 0 decap_w0
xfeed_12621 1 0 decap_w0
xfeed_12620 1 0 decap_w0
xfeed_16939 1 0 decap_w0
xfeed_16938 1 0 decap_w0
xfeed_16937 1 0 decap_w0
xfeed_16936 1 0 decap_w0
xfeed_16935 1 0 decap_w0
xfeed_16934 1 0 decap_w0
xfeed_6429 1 0 decap_w0
xfeed_6428 1 0 decap_w0
xfeed_6427 1 0 decap_w0
xfeed_6426 1 0 decap_w0
xfeed_6425 1 0 decap_w0
xfeed_6424 1 0 decap_w0
xfeed_6423 1 0 decap_w0
xfeed_6422 1 0 decap_w0
xfeed_6421 1 0 decap_w0
xfeed_6420 1 0 decap_w0
xsubckt_75_nexor2_x0 1 0 158 117 22 nexor2_x0
xfeed_2110 1 0 decap_w0
xfeed_2111 1 0 decap_w0
xfeed_2112 1 0 decap_w0
xfeed_2113 1 0 decap_w0
xfeed_2114 1 0 decap_w0
xfeed_2115 1 0 decap_w0
xfeed_2116 1 0 decap_w0
xfeed_2117 1 0 decap_w0
xfeed_2118 1 0 decap_w0
xfeed_2119 1 0 decap_w0
xfeed_27789 1 0 decap_w0
xfeed_27788 1 0 decap_w0
xfeed_27787 1 0 decap_w0
xfeed_27786 1 0 decap_w0
xfeed_27785 1 0 decap_w0
xfeed_27784 1 0 decap_w0
xfeed_27783 1 0 decap_w0
xfeed_27782 1 0 tie
xfeed_27781 1 0 decap_w0
xfeed_27780 1 0 decap_w0
xfeed_23479 1 0 decap_w0
xfeed_23478 1 0 decap_w0
xfeed_23477 1 0 decap_w0
xfeed_23476 1 0 decap_w0
xfeed_23475 1 0 decap_w0
xfeed_23474 1 0 decap_w0
xfeed_23473 1 0 decap_w0
xfeed_23472 1 0 decap_w0
xfeed_23471 1 0 decap_w0
xfeed_23470 1 0 decap_w0
xfeed_22949 1 0 decap_w0
xfeed_22948 1 0 decap_w0
xfeed_22947 1 0 decap_w0
xfeed_22946 1 0 decap_w0
xfeed_22945 1 0 decap_w0
xfeed_22944 1 0 decap_w0
xfeed_22943 1 0 decap_w0
xfeed_22942 1 0 decap_w0
xfeed_22941 1 0 decap_w0
xfeed_22940 1 0 decap_w0
xfeed_17479 1 0 decap_w0
xfeed_17478 1 0 decap_w0
xfeed_17477 1 0 decap_w0
xfeed_17476 1 0 decap_w0
xfeed_17475 1 0 decap_w0
xfeed_17474 1 0 decap_w0
xfeed_17473 1 0 decap_w0
xfeed_17472 1 0 decap_w0
xfeed_17471 1 0 decap_w0
xfeed_17470 1 0 decap_w0
xfeed_16940 1 0 decap_w0
xfeed_13169 1 0 decap_w0
xfeed_13168 1 0 decap_w0
xfeed_13167 1 0 decap_w0
xfeed_13166 1 0 decap_w0
xfeed_13165 1 0 decap_w0
xfeed_13164 1 0 decap_w0
xfeed_13163 1 0 decap_w0
xfeed_13162 1 0 decap_w0
xfeed_13161 1 0 decap_w0
xfeed_13160 1 0 decap_w0
xfeed_12639 1 0 decap_w0
xfeed_12638 1 0 decap_w0
xfeed_12637 1 0 decap_w0
xfeed_12636 1 0 decap_w0
xfeed_12635 1 0 decap_w0
xfeed_12634 1 0 decap_w0
xfeed_12633 1 0 decap_w0
xfeed_12632 1 0 decap_w0
xfeed_12631 1 0 decap_w0
xfeed_12630 1 0 decap_w0
xsubckt_57_nexor2_x0 1 0 41 61 171 nexor2_x0
xfeed_16949 1 0 decap_w0
xfeed_16948 1 0 decap_w0
xfeed_16947 1 0 decap_w0
xfeed_16946 1 0 decap_w0
xfeed_16945 1 0 decap_w0
xfeed_16944 1 0 decap_w0
xfeed_16943 1 0 decap_w0
xfeed_16942 1 0 decap_w0
xfeed_16941 1 0 decap_w0
xfeed_6439 1 0 decap_w0
xfeed_6438 1 0 decap_w0
xfeed_6437 1 0 decap_w0
xfeed_6436 1 0 decap_w0
xfeed_6435 1 0 decap_w0
xfeed_6434 1 0 decap_w0
xfeed_6433 1 0 decap_w0
xfeed_6432 1 0 decap_w0
xfeed_6431 1 0 decap_w0
xfeed_6430 1 0 decap_w0
xfeed_5909 1 0 decap_w0
xfeed_5908 1 0 decap_w0
xfeed_5907 1 0 decap_w0
xfeed_5906 1 0 decap_w0
xfeed_5905 1 0 decap_w0
xfeed_5904 1 0 decap_w0
xfeed_5903 1 0 decap_w0
xfeed_5902 1 0 decap_w0
xfeed_5901 1 0 decap_w0
xfeed_5900 1 0 decap_w0
xfeed_2129 1 0 decap_w0
xfeed_2128 1 0 decap_w0
xfeed_2127 1 0 decap_w0
xfeed_2126 1 0 decap_w0
xfeed_2125 1 0 decap_w0
xfeed_2124 1 0 decap_w0
xsubckt_48_nexor2_x0 1 0 177 178 10 nexor2_x0
xsubckt_9_nexor2_x0 1 0 134 3 133 nexor2_x0
xfeed_2120 1 0 decap_w0
xfeed_2121 1 0 decap_w0
xfeed_2122 1 0 decap_w0
xfeed_2123 1 0 decap_w0
xfeed_28409 1 0 decap_w0
xfeed_28408 1 0 decap_w0
xfeed_28407 1 0 decap_w0
xfeed_28406 1 0 decap_w0
xfeed_28405 1 0 decap_w0
xfeed_28404 1 0 decap_w0
xfeed_28403 1 0 decap_w0
xfeed_28402 1 0 decap_w0
xfeed_28401 1 0 decap_w0
xfeed_28400 1 0 decap_w0
xfeed_27799 1 0 decap_w0
xfeed_27798 1 0 decap_w0
xfeed_27797 1 0 decap_w0
xfeed_27796 1 0 decap_w0
xfeed_27795 1 0 decap_w0
xfeed_27794 1 0 decap_w0
xfeed_27793 1 0 decap_w0
xfeed_27792 1 0 decap_w0
xfeed_27791 1 0 decap_w0
xfeed_27790 1 0 decap_w0
xfeed_23489 1 0 decap_w0
xfeed_23488 1 0 decap_w0
xfeed_23487 1 0 decap_w0
xfeed_23486 1 0 decap_w0
xfeed_23485 1 0 decap_w0
xfeed_23484 1 0 decap_w0
xfeed_23483 1 0 decap_w0
xfeed_23482 1 0 decap_w0
xfeed_23481 1 0 decap_w0
xfeed_23480 1 0 decap_w0
xfeed_22959 1 0 decap_w0
xfeed_22958 1 0 decap_w0
xfeed_22957 1 0 decap_w0
xfeed_22956 1 0 decap_w0
xfeed_22955 1 0 decap_w0
xfeed_22954 1 0 decap_w0
xfeed_22953 1 0 decap_w0
xfeed_22952 1 0 decap_w0
xfeed_22951 1 0 decap_w0
xfeed_22950 1 0 decap_w0
xfeed_17486 1 0 decap_w0
xfeed_17485 1 0 decap_w0
xfeed_17484 1 0 decap_w0
xfeed_17483 1 0 decap_w0
xfeed_17482 1 0 decap_w0
xfeed_17481 1 0 decap_w0
xfeed_17480 1 0 decap_w0
xfeed_13179 1 0 decap_w0
xfeed_13178 1 0 decap_w0
xfeed_13177 1 0 decap_w0
xfeed_13176 1 0 decap_w0
xfeed_13175 1 0 decap_w0
xfeed_13174 1 0 decap_w0
xfeed_13173 1 0 decap_w0
xfeed_13172 1 0 decap_w0
xfeed_13171 1 0 decap_w0
xfeed_13170 1 0 decap_w0
xfeed_12647 1 0 decap_w0
xfeed_12646 1 0 decap_w0
xfeed_12645 1 0 decap_w0
xfeed_12644 1 0 decap_w0
xfeed_12643 1 0 decap_w0
xfeed_12642 1 0 decap_w0
xfeed_12641 1 0 decap_w0
xfeed_12640 1 0 decap_w0
xsubckt_39_nexor2_x0 1 0 183 135 182 nexor2_x0
xfeed_100 1 0 decap_w0
xfeed_101 1 0 decap_w0
xfeed_102 1 0 decap_w0
xfeed_103 1 0 decap_w0
xfeed_104 1 0 decap_w0
xfeed_105 1 0 decap_w0
xfeed_106 1 0 decap_w0
xfeed_107 1 0 decap_w0
xfeed_108 1 0 decap_w0
xfeed_109 1 0 decap_w0
xfeed_30109 1 0 decap_w0
xfeed_30108 1 0 decap_w0
xfeed_30107 1 0 decap_w0
xfeed_30106 1 0 decap_w0
xfeed_30105 1 0 decap_w0
xfeed_30104 1 0 decap_w0
xfeed_30103 1 0 decap_w0
xfeed_30102 1 0 decap_w0
xfeed_30101 1 0 decap_w0
xfeed_30100 1 0 decap_w0
xfeed_17489 1 0 decap_w0
xfeed_17488 1 0 decap_w0
xfeed_17487 1 0 decap_w0
xfeed_16959 1 0 decap_w0
xfeed_16958 1 0 decap_w0
xfeed_16957 1 0 decap_w0
xfeed_16956 1 0 decap_w0
xfeed_16955 1 0 decap_w0
xfeed_16954 1 0 decap_w0
xfeed_16953 1 0 decap_w0
xfeed_16952 1 0 decap_w0
xfeed_16951 1 0 decap_w0
xfeed_16950 1 0 decap_w0
xfeed_12649 1 0 decap_w0
xfeed_12648 1 0 decap_w0
xfeed_6449 1 0 decap_w0
xfeed_6448 1 0 decap_w0
xfeed_6447 1 0 decap_w0
xfeed_6446 1 0 decap_w0
xfeed_6445 1 0 decap_w0
xfeed_6444 1 0 decap_w0
xfeed_6443 1 0 decap_w0
xfeed_6442 1 0 decap_w0
xfeed_6441 1 0 decap_w0
xfeed_6440 1 0 decap_w0
xfeed_5919 1 0 decap_w0
xfeed_5918 1 0 decap_w0
xfeed_5917 1 0 decap_w0
xfeed_5916 1 0 decap_w0
xfeed_5915 1 0 decap_w0
xfeed_5914 1 0 decap_w0
xfeed_5913 1 0 decap_w0
xfeed_5912 1 0 decap_w0
xfeed_5911 1 0 decap_w0
xfeed_5910 1 0 decap_w0
xfeed_2139 1 0 decap_w0
xfeed_2138 1 0 decap_w0
xfeed_2137 1 0 decap_w0
xfeed_2136 1 0 decap_w0
xfeed_2135 1 0 decap_w0
xfeed_2134 1 0 decap_w0
xfeed_2133 1 0 decap_w0
xfeed_2132 1 0 decap_w0
xfeed_2131 1 0 decap_w0
xfeed_2130 1 0 decap_w0
xfeed_1600 1 0 decap_w0
xfeed_1601 1 0 decap_w0
xfeed_1602 1 0 decap_w0
xfeed_1603 1 0 decap_w0
xfeed_1604 1 0 decap_w0
xfeed_1605 1 0 decap_w0
xfeed_1606 1 0 decap_w0
xfeed_1607 1 0 decap_w0
xfeed_1608 1 0 decap_w0
xfeed_1609 1 0 decap_w0
xfeed_28419 1 0 decap_w0
xfeed_28418 1 0 decap_w0
xfeed_28417 1 0 decap_w0
xfeed_28416 1 0 decap_w0
xfeed_28415 1 0 decap_w0
xfeed_28414 1 0 decap_w0
xfeed_28413 1 0 decap_w0
xfeed_28412 1 0 decap_w0
xfeed_28411 1 0 decap_w0
xfeed_28410 1 0 decap_w0
xfeed_24109 1 0 decap_w0
xfeed_24108 1 0 decap_w0
xfeed_24107 1 0 decap_w0
xfeed_24106 1 0 decap_w0
xfeed_24105 1 0 decap_w0
xfeed_24104 1 0 decap_w0
xfeed_24103 1 0 decap_w0
xfeed_24102 1 0 decap_w0
xfeed_24101 1 0 decap_w0
xfeed_24100 1 0 decap_w0
xfeed_23499 1 0 decap_w0
xfeed_23498 1 0 decap_w0
xfeed_23497 1 0 decap_w0
xfeed_23496 1 0 decap_w0
xfeed_23495 1 0 decap_w0
xfeed_23494 1 0 decap_w0
xfeed_23493 1 0 decap_w0
xfeed_23492 1 0 decap_w0
xfeed_23491 1 0 decap_w0
xfeed_23490 1 0 decap_w0
xfeed_22969 1 0 decap_w0
xfeed_22968 1 0 decap_w0
xfeed_22967 1 0 decap_w0
xfeed_22966 1 0 decap_w0
xfeed_22965 1 0 decap_w0
xfeed_22964 1 0 decap_w0
xfeed_22963 1 0 decap_w0
xfeed_22962 1 0 decap_w0
xfeed_22961 1 0 decap_w0
xfeed_22960 1 0 decap_w0
xfeed_18109 1 0 decap_w0
xfeed_18108 1 0 decap_w0
xfeed_18107 1 0 decap_w0
xfeed_18106 1 0 decap_w0
xfeed_18105 1 0 decap_w0
xfeed_18104 1 0 decap_w0
xfeed_18103 1 0 decap_w0
xfeed_18102 1 0 decap_w0
xfeed_18101 1 0 decap_w0
xfeed_18100 1 0 decap_w0
xfeed_17493 1 0 decap_w0
xfeed_17492 1 0 decap_w0
xfeed_17491 1 0 decap_w0
xfeed_17490 1 0 decap_w0
xfeed_13189 1 0 decap_w0
xfeed_13188 1 0 decap_w0
xfeed_13187 1 0 decap_w0
xfeed_13186 1 0 decap_w0
xfeed_13185 1 0 decap_w0
xfeed_13184 1 0 decap_w0
xfeed_13183 1 0 decap_w0
xfeed_13182 1 0 decap_w0
xfeed_13181 1 0 decap_w0
xfeed_13180 1 0 decap_w0
xfeed_12654 1 0 decap_w0
xfeed_12653 1 0 decap_w0
xfeed_12652 1 0 decap_w0
xfeed_12651 1 0 decap_w0
xfeed_12650 1 0 decap_w0
xsubckt_23_xor2_x0 1 0 52 62 124 xor2_x0
xfeed_110 1 0 decap_w0
xfeed_111 1 0 decap_w0
xfeed_112 1 0 decap_w0
xfeed_113 1 0 decap_w0
xfeed_114 1 0 decap_w0
xfeed_115 1 0 decap_w0
xfeed_116 1 0 decap_w0
xfeed_117 1 0 decap_w0
xfeed_118 1 0 decap_w0
xfeed_119 1 0 decap_w0
xfeed_30119 1 0 decap_w0
xfeed_30118 1 0 decap_w0
xfeed_30117 1 0 decap_w0
xfeed_30116 1 0 decap_w0
xfeed_30115 1 0 decap_w0
xfeed_30114 1 0 decap_w0
xfeed_30113 1 0 decap_w0
xfeed_30112 1 0 decap_w0
xfeed_30111 1 0 decap_w0
xfeed_30110 1 0 decap_w0
xfeed_17499 1 0 decap_w0
xfeed_17498 1 0 decap_w0
xfeed_17497 1 0 decap_w0
xfeed_17496 1 0 decap_w0
xfeed_17495 1 0 decap_w0
xfeed_17494 1 0 decap_w0
xfeed_16969 1 0 decap_w0
xfeed_16968 1 0 decap_w0
xfeed_16967 1 0 decap_w0
xfeed_16966 1 0 decap_w0
xfeed_16965 1 0 decap_w0
xfeed_16964 1 0 decap_w0
xfeed_16963 1 0 decap_w0
xfeed_16962 1 0 decap_w0
xfeed_16961 1 0 decap_w0
xfeed_16960 1 0 decap_w0
xfeed_12659 1 0 decap_w0
xfeed_12658 1 0 decap_w0
xfeed_12657 1 0 decap_w0
xfeed_12656 1 0 decap_w0
xfeed_12655 1 0 decap_w0
xfeed_6459 1 0 decap_w0
xfeed_6458 1 0 decap_w0
xfeed_6457 1 0 decap_w0
xfeed_6456 1 0 decap_w0
xfeed_6455 1 0 decap_w0
xfeed_6454 1 0 decap_w0
xfeed_6453 1 0 decap_w0
xfeed_6452 1 0 decap_w0
xfeed_6451 1 0 decap_w0
xfeed_6450 1 0 decap_w0
xfeed_5929 1 0 decap_w0
xfeed_5928 1 0 decap_w0
xfeed_5927 1 0 decap_w0
xfeed_5926 1 0 decap_w0
xfeed_5925 1 0 decap_w0
xfeed_5924 1 0 decap_w0
xfeed_5923 1 0 decap_w0
xfeed_5922 1 0 decap_w0
xfeed_5921 1 0 decap_w0
xfeed_5920 1 0 decap_w0
xfeed_2149 1 0 decap_w0
xfeed_2148 1 0 decap_w0
xfeed_2147 1 0 decap_w0
xfeed_2146 1 0 decap_w0
xfeed_2145 1 0 decap_w0
xfeed_2144 1 0 decap_w0
xfeed_2143 1 0 decap_w0
xfeed_2142 1 0 decap_w0
xfeed_2141 1 0 decap_w0
xfeed_2140 1 0 decap_w0
xsubckt_19_xor2_x0 1 0 36 38 127 xor2_x0
xsubckt_99_nexor2_x0 1 0 140 143 139 nexor2_x0
xfeed_1610 1 0 decap_w0
xfeed_1611 1 0 decap_w0
xfeed_1612 1 0 decap_w0
xfeed_1613 1 0 decap_w0
xfeed_1614 1 0 decap_w0
xfeed_1615 1 0 decap_w0
xfeed_1616 1 0 decap_w0
xfeed_1617 1 0 decap_w0
xfeed_1618 1 0 decap_w0
xfeed_1619 1 0 decap_w0
xfeed_28429 1 0 decap_w0
xfeed_28428 1 0 decap_w0
xfeed_28427 1 0 decap_w0
xfeed_28426 1 0 decap_w0
xfeed_28425 1 0 decap_w0
xfeed_28424 1 0 decap_w0
xfeed_28423 1 0 decap_w0
xfeed_28422 1 0 decap_w0
xfeed_28421 1 0 decap_w0
xfeed_28420 1 0 decap_w0
xfeed_24119 1 0 decap_w0
xfeed_24118 1 0 decap_w0
xfeed_24117 1 0 decap_w0
xfeed_24116 1 0 decap_w0
xfeed_24115 1 0 decap_w0
xfeed_24114 1 0 decap_w0
xfeed_24113 1 0 decap_w0
xfeed_24112 1 0 decap_w0
xfeed_24111 1 0 decap_w0
xfeed_24110 1 0 tie
xfeed_22979 1 0 decap_w0
xfeed_22978 1 0 decap_w0
xfeed_22977 1 0 decap_w0
xfeed_22976 1 0 decap_w0
xfeed_22975 1 0 decap_w0
xfeed_22974 1 0 decap_w0
xfeed_22973 1 0 decap_w0
xfeed_22972 1 0 tie
xfeed_22971 1 0 decap_w0
xfeed_22970 1 0 decap_w0
xfeed_18119 1 0 decap_w0
xfeed_18118 1 0 decap_w0
xfeed_18117 1 0 decap_w0
xfeed_18116 1 0 decap_w0
xfeed_18115 1 0 decap_w0
xfeed_18114 1 0 decap_w0
xfeed_18113 1 0 decap_w0
xfeed_18112 1 0 decap_w0
xfeed_18111 1 0 decap_w0
xfeed_18110 1 0 decap_w0
xfeed_13199 1 0 decap_w0
xfeed_13198 1 0 decap_w0
xfeed_13197 1 0 decap_w0
xfeed_13196 1 0 decap_w0
xfeed_13195 1 0 decap_w0
xfeed_13194 1 0 decap_w0
xfeed_13193 1 0 decap_w0
xfeed_13192 1 0 decap_w0
xfeed_13191 1 0 decap_w0
xfeed_13190 1 0 decap_w0
xfeed_12661 1 0 decap_w0
xfeed_12660 1 0 decap_w0
xfeed_120 1 0 decap_w0
xfeed_121 1 0 decap_w0
xfeed_122 1 0 decap_w0
xfeed_123 1 0 decap_w0
xfeed_124 1 0 decap_w0
xfeed_125 1 0 decap_w0
xfeed_126 1 0 decap_w0
xfeed_127 1 0 decap_w0
xfeed_128 1 0 decap_w0
xfeed_129 1 0 decap_w0
xfeed_30129 1 0 decap_w0
xfeed_30128 1 0 decap_w0
xfeed_30127 1 0 decap_w0
xfeed_30126 1 0 decap_w0
xfeed_30125 1 0 decap_w0
xfeed_30124 1 0 decap_w0
xfeed_30123 1 0 decap_w0
xfeed_30122 1 0 decap_w0
xfeed_30121 1 0 decap_w0
xfeed_30120 1 0 decap_w0
xfeed_16979 1 0 decap_w0
xfeed_16978 1 0 decap_w0
xfeed_16977 1 0 decap_w0
xfeed_16976 1 0 decap_w0
xfeed_16975 1 0 decap_w0
xfeed_16974 1 0 decap_w0
xfeed_16973 1 0 decap_w0
xfeed_16972 1 0 decap_w0
xfeed_16971 1 0 decap_w0
xfeed_16970 1 0 decap_w0
xfeed_12669 1 0 decap_w0
xfeed_12668 1 0 decap_w0
xfeed_12667 1 0 decap_w0
xfeed_12666 1 0 decap_w0
xfeed_12665 1 0 decap_w0
xfeed_12664 1 0 decap_w0
xfeed_12663 1 0 decap_w0
xfeed_12662 1 0 decap_w0
xfeed_6469 1 0 decap_w0
xfeed_6468 1 0 decap_w0
xfeed_6467 1 0 decap_w0
xfeed_6466 1 0 decap_w0
xfeed_6465 1 0 decap_w0
xfeed_6464 1 0 decap_w0
xfeed_6463 1 0 decap_w0
xfeed_6462 1 0 decap_w0
xfeed_6461 1 0 decap_w0
xfeed_6460 1 0 decap_w0
xfeed_5939 1 0 decap_w0
xfeed_5938 1 0 decap_w0
xfeed_5937 1 0 decap_w0
xfeed_5936 1 0 decap_w0
xfeed_5935 1 0 decap_w0
xfeed_5934 1 0 decap_w0
xfeed_5933 1 0 decap_w0
xfeed_5932 1 0 decap_w0
xfeed_5931 1 0 decap_w0
xfeed_5930 1 0 decap_w0
xfeed_2159 1 0 decap_w0
xfeed_2158 1 0 decap_w0
xfeed_2157 1 0 decap_w0
xfeed_2156 1 0 decap_w0
xfeed_2155 1 0 decap_w0
xfeed_2154 1 0 decap_w0
xfeed_2153 1 0 decap_w0
xfeed_2152 1 0 decap_w0
xfeed_2151 1 0 decap_w0
xfeed_2150 1 0 decap_w0
xfeed_1620 1 0 decap_w0
xfeed_1621 1 0 decap_w0
xfeed_1622 1 0 decap_w0
xfeed_1623 1 0 decap_w0
xfeed_1624 1 0 decap_w0
xfeed_1625 1 0 decap_w0
xfeed_1626 1 0 decap_w0
xfeed_1627 1 0 decap_w0
xfeed_1628 1 0 decap_w0
xfeed_1629 1 0 decap_w0
xfeed_28439 1 0 decap_w0
xfeed_28438 1 0 decap_w0
xfeed_28437 1 0 decap_w0
xfeed_28436 1 0 decap_w0
xfeed_28435 1 0 decap_w0
xfeed_28434 1 0 decap_w0
xfeed_28433 1 0 decap_w0
xfeed_28432 1 0 decap_w0
xfeed_28431 1 0 decap_w0
xfeed_28430 1 0 decap_w0
xfeed_27909 1 0 decap_w0
xfeed_27908 1 0 decap_w0
xfeed_27907 1 0 decap_w0
xfeed_27906 1 0 decap_w0
xfeed_27905 1 0 decap_w0
xfeed_27904 1 0 decap_w0
xfeed_27903 1 0 decap_w0
xfeed_27902 1 0 decap_w0
xfeed_27901 1 0 decap_w0
xfeed_27900 1 0 decap_w0
xfeed_24129 1 0 decap_w0
xfeed_24128 1 0 decap_w0
xfeed_24127 1 0 decap_w0
xfeed_24126 1 0 decap_w0
xfeed_24125 1 0 decap_w0
xfeed_24124 1 0 decap_w0
xfeed_24123 1 0 decap_w0
xfeed_24122 1 0 decap_w0
xfeed_24121 1 0 decap_w0
xfeed_24120 1 0 decap_w0
xfeed_22989 1 0 decap_w0
xfeed_22988 1 0 decap_w0
xfeed_22987 1 0 decap_w0
xfeed_22986 1 0 decap_w0
xfeed_22985 1 0 decap_w0
xfeed_22984 1 0 decap_w0
xfeed_22983 1 0 decap_w0
xfeed_22982 1 0 decap_w0
xfeed_22981 1 0 decap_w0
xfeed_22980 1 0 decap_w0
xfeed_18129 1 0 decap_w0
xfeed_18128 1 0 decap_w0
xfeed_18127 1 0 decap_w0
xfeed_18126 1 0 decap_w0
xfeed_18125 1 0 decap_w0
xfeed_18124 1 0 decap_w0
xfeed_18123 1 0 decap_w0
xfeed_18122 1 0 decap_w0
xfeed_18121 1 0 decap_w0
xfeed_18120 1 0 decap_w0
xfeed_130 1 0 decap_w0
xfeed_131 1 0 decap_w0
xfeed_132 1 0 decap_w0
xfeed_133 1 0 decap_w0
xfeed_134 1 0 decap_w0
xfeed_135 1 0 decap_w0
xfeed_136 1 0 decap_w0
xfeed_137 1 0 decap_w0
xfeed_138 1 0 decap_w0
xfeed_139 1 0 decap_w0
xfeed_30139 1 0 decap_w0
xfeed_30138 1 0 decap_w0
xfeed_30137 1 0 decap_w0
xfeed_30136 1 0 decap_w0
xfeed_30135 1 0 decap_w0
xfeed_30134 1 0 decap_w0
xfeed_30133 1 0 decap_w0
xfeed_30132 1 0 decap_w0
xfeed_30131 1 0 decap_w0
xfeed_30130 1 0 decap_w0
xfeed_16989 1 0 decap_w0
xfeed_16988 1 0 decap_w0
xfeed_16987 1 0 decap_w0
xfeed_16986 1 0 decap_w0
xfeed_16985 1 0 decap_w0
xfeed_16984 1 0 decap_w0
xfeed_16983 1 0 decap_w0
xfeed_16982 1 0 decap_w0
xfeed_16981 1 0 tie
xfeed_16980 1 0 decap_w0
xfeed_12679 1 0 decap_w0
xfeed_12678 1 0 decap_w0
xfeed_12677 1 0 decap_w0
xfeed_12676 1 0 decap_w0
xfeed_12675 1 0 decap_w0
xfeed_12674 1 0 decap_w0
xfeed_12673 1 0 decap_w0
xfeed_12672 1 0 decap_w0
xfeed_12671 1 0 decap_w0
xfeed_12670 1 0 decap_w0
xfeed_6479 1 0 decap_w0
xfeed_6478 1 0 decap_w0
xfeed_6477 1 0 decap_w0
xfeed_6476 1 0 decap_w0
xfeed_6475 1 0 decap_w0
xfeed_6474 1 0 decap_w0
xfeed_6473 1 0 decap_w0
xfeed_6472 1 0 decap_w0
xfeed_6471 1 0 decap_w0
xfeed_6470 1 0 decap_w0
xfeed_5946 1 0 decap_w0
xfeed_5945 1 0 decap_w0
xfeed_5944 1 0 decap_w0
xfeed_5943 1 0 decap_w0
xfeed_5942 1 0 decap_w0
xfeed_5941 1 0 decap_w0
xfeed_5940 1 0 decap_w0
xfeed_2169 1 0 decap_w0
xfeed_2168 1 0 decap_w0
xfeed_2167 1 0 decap_w0
xfeed_2166 1 0 decap_w0
xfeed_2165 1 0 decap_w0
xfeed_2164 1 0 decap_w0
xfeed_2163 1 0 decap_w0
xfeed_2162 1 0 decap_w0
xfeed_2161 1 0 decap_w0
xfeed_2160 1 0 decap_w0
xfeed_1630 1 0 decap_w0
xfeed_1631 1 0 decap_w0
xfeed_1632 1 0 decap_w0
xfeed_1633 1 0 decap_w0
xfeed_1634 1 0 decap_w0
xfeed_1635 1 0 decap_w0
xfeed_1636 1 0 decap_w0
xfeed_1637 1 0 decap_w0
xfeed_1638 1 0 decap_w0
xfeed_1639 1 0 decap_w0
xfeed_28449 1 0 decap_w0
xfeed_28448 1 0 decap_w0
xfeed_28447 1 0 decap_w0
xfeed_28446 1 0 decap_w0
xfeed_28445 1 0 decap_w0
xfeed_28444 1 0 decap_w0
xfeed_28443 1 0 decap_w0
xfeed_28442 1 0 decap_w0
xfeed_28441 1 0 decap_w0
xfeed_28440 1 0 decap_w0
xfeed_27919 1 0 decap_w0
xfeed_27918 1 0 decap_w0
xfeed_27917 1 0 decap_w0
xfeed_27916 1 0 decap_w0
xfeed_27915 1 0 decap_w0
xfeed_27914 1 0 decap_w0
xfeed_27913 1 0 decap_w0
xfeed_27912 1 0 decap_w0
xfeed_27911 1 0 decap_w0
xfeed_27910 1 0 decap_w0
xfeed_24139 1 0 decap_w0
xfeed_24138 1 0 decap_w0
xfeed_24137 1 0 decap_w0
xfeed_24136 1 0 decap_w0
xfeed_24135 1 0 decap_w0
xfeed_24134 1 0 decap_w0
xfeed_24133 1 0 decap_w0
xfeed_24132 1 0 decap_w0
xfeed_24131 1 0 decap_w0
xfeed_24130 1 0 decap_w0
xfeed_23609 1 0 decap_w0
xfeed_23608 1 0 decap_w0
xfeed_23607 1 0 decap_w0
xfeed_23606 1 0 decap_w0
xfeed_23605 1 0 decap_w0
xfeed_23604 1 0 decap_w0
xfeed_23603 1 0 decap_w0
xfeed_23602 1 0 decap_w0
xfeed_23601 1 0 decap_w0
xfeed_23600 1 0 decap_w0
xfeed_22999 1 0 decap_w0
xfeed_22998 1 0 decap_w0
xfeed_22997 1 0 decap_w0
xfeed_22996 1 0 decap_w0
xfeed_22995 1 0 decap_w0
xfeed_22994 1 0 decap_w0
xfeed_22993 1 0 decap_w0
xfeed_22992 1 0 decap_w0
xfeed_22991 1 0 decap_w0
xfeed_22990 1 0 decap_w0
xfeed_18139 1 0 decap_w0
xfeed_18138 1 0 decap_w0
xfeed_18137 1 0 decap_w0
xfeed_18136 1 0 decap_w0
xfeed_18135 1 0 decap_w0
xfeed_18134 1 0 decap_w0
xfeed_18133 1 0 decap_w0
xfeed_18132 1 0 decap_w0
xfeed_18131 1 0 decap_w0
xfeed_18130 1 0 decap_w0
xfeed_17609 1 0 decap_w0
xfeed_17608 1 0 decap_w0
xfeed_17607 1 0 decap_w0
xfeed_17606 1 0 decap_w0
xfeed_17605 1 0 decap_w0
xfeed_17604 1 0 decap_w0
xfeed_17603 1 0 decap_w0
xfeed_17602 1 0 decap_w0
xfeed_17601 1 0 decap_w0
xfeed_17600 1 0 decap_w0
xfeed_5949 1 0 decap_w0
xfeed_5948 1 0 decap_w0
xfeed_5947 1 0 decap_w0
xfeed_140 1 0 decap_w0
xfeed_141 1 0 decap_w0
xfeed_142 1 0 decap_w0
xfeed_143 1 0 decap_w0
xfeed_144 1 0 decap_w0
xfeed_145 1 0 decap_w0
xfeed_146 1 0 decap_w0
xfeed_147 1 0 decap_w0
xfeed_148 1 0 decap_w0
xfeed_149 1 0 decap_w0
xfeed_30148 1 0 decap_w0
xfeed_30147 1 0 decap_w0
xfeed_30146 1 0 decap_w0
xfeed_30145 1 0 decap_w0
xfeed_30144 1 0 decap_w0
xfeed_30143 1 0 decap_w0
xfeed_30142 1 0 decap_w0
xfeed_30141 1 0 decap_w0
xfeed_30140 1 0 decap_w0
xfeed_16999 1 0 decap_w0
xfeed_16998 1 0 decap_w0
xfeed_16997 1 0 decap_w0
xfeed_16996 1 0 decap_w0
xfeed_16995 1 0 decap_w0
xfeed_16994 1 0 decap_w0
xfeed_16993 1 0 decap_w0
xfeed_16992 1 0 decap_w0
xfeed_16991 1 0 decap_w0
xfeed_16990 1 0 decap_w0
xfeed_12689 1 0 decap_w0
xfeed_12688 1 0 decap_w0
xfeed_12687 1 0 decap_w0
xfeed_12686 1 0 decap_w0
xfeed_12685 1 0 decap_w0
xfeed_12684 1 0 decap_w0
xfeed_12683 1 0 decap_w0
xfeed_12682 1 0 decap_w0
xfeed_12681 1 0 decap_w0
xfeed_12680 1 0 decap_w0
xfeed_6489 1 0 decap_w0
xfeed_6488 1 0 decap_w0
xfeed_6487 1 0 decap_w0
xfeed_6486 1 0 decap_w0
xfeed_6485 1 0 decap_w0
xfeed_6484 1 0 decap_w0
xfeed_6483 1 0 decap_w0
xfeed_6482 1 0 decap_w0
xfeed_6481 1 0 decap_w0
xfeed_6480 1 0 decap_w0
xfeed_5953 1 0 decap_w0
xfeed_5952 1 0 decap_w0
xfeed_5951 1 0 decap_w0
xfeed_5950 1 0 decap_w0
xfeed_2179 1 0 decap_w0
xfeed_2178 1 0 decap_w0
xfeed_2177 1 0 decap_w0
xfeed_2176 1 0 decap_w0
xfeed_2175 1 0 decap_w0
xfeed_2174 1 0 decap_w0
xfeed_2173 1 0 decap_w0
xfeed_2172 1 0 decap_w0
xfeed_2171 1 0 decap_w0
xfeed_2170 1 0 decap_w0
xfeed_1640 1 0 decap_w0
xfeed_1641 1 0 decap_w0
xfeed_1642 1 0 decap_w0
xfeed_1643 1 0 decap_w0
xfeed_1644 1 0 decap_w0
xfeed_1645 1 0 decap_w0
xfeed_1646 1 0 decap_w0
xfeed_1647 1 0 decap_w0
xfeed_1648 1 0 decap_w0
xfeed_1649 1 0 decap_w0
xfeed_30149 1 0 decap_w0
xfeed_28459 1 0 decap_w0
xfeed_28458 1 0 decap_w0
xfeed_28457 1 0 decap_w0
xfeed_28456 1 0 decap_w0
xfeed_28455 1 0 decap_w0
xfeed_28454 1 0 decap_w0
xfeed_28453 1 0 decap_w0
xfeed_28452 1 0 decap_w0
xfeed_28451 1 0 decap_w0
xfeed_28450 1 0 decap_w0
xfeed_27929 1 0 decap_w0
xfeed_27928 1 0 decap_w0
xfeed_27927 1 0 decap_w0
xfeed_27926 1 0 decap_w0
xfeed_27925 1 0 decap_w0
xfeed_27924 1 0 decap_w0
xfeed_27923 1 0 decap_w0
xfeed_27922 1 0 decap_w0
xfeed_27921 1 0 decap_w0
xfeed_27920 1 0 decap_w0
xfeed_24149 1 0 decap_w0
xfeed_24148 1 0 decap_w0
xfeed_24147 1 0 decap_w0
xfeed_24146 1 0 decap_w0
xfeed_24145 1 0 decap_w0
xfeed_24144 1 0 decap_w0
xfeed_24143 1 0 decap_w0
xfeed_24142 1 0 decap_w0
xfeed_24141 1 0 decap_w0
xfeed_24140 1 0 decap_w0
xfeed_23619 1 0 decap_w0
xfeed_23618 1 0 decap_w0
xfeed_23617 1 0 decap_w0
xfeed_23616 1 0 decap_w0
xfeed_23615 1 0 decap_w0
xfeed_23614 1 0 decap_w0
xfeed_23613 1 0 decap_w0
xfeed_23612 1 0 decap_w0
xfeed_23611 1 0 decap_w0
xfeed_23610 1 0 decap_w0
xfeed_18149 1 0 decap_w0
xfeed_18148 1 0 decap_w0
xfeed_18147 1 0 decap_w0
xfeed_18146 1 0 decap_w0
xfeed_18145 1 0 decap_w0
xfeed_18144 1 0 decap_w0
xfeed_18143 1 0 decap_w0
xfeed_18142 1 0 decap_w0
xfeed_18141 1 0 decap_w0
xfeed_18140 1 0 decap_w0
xfeed_17619 1 0 decap_w0
xfeed_17618 1 0 decap_w0
xfeed_17617 1 0 decap_w0
xfeed_17616 1 0 decap_w0
xfeed_17615 1 0 decap_w0
xfeed_17614 1 0 decap_w0
xfeed_17613 1 0 decap_w0
xfeed_17612 1 0 decap_w0
xfeed_17611 1 0 decap_w0
xfeed_17610 1 0 decap_w0
xfeed_13309 1 0 decap_w0
xfeed_13308 1 0 decap_w0
xfeed_13307 1 0 decap_w0
xfeed_13306 1 0 decap_w0
xfeed_13305 1 0 decap_w0
xfeed_13304 1 0 decap_w0
xfeed_13303 1 0 decap_w0
xfeed_13302 1 0 decap_w0
xfeed_13301 1 0 decap_w0
xfeed_13300 1 0 decap_w0
xfeed_5959 1 0 decap_w0
xfeed_5958 1 0 decap_w0
xfeed_5957 1 0 decap_w0
xfeed_5956 1 0 decap_w0
xfeed_5955 1 0 decap_w0
xfeed_5954 1 0 decap_w0
xfeed_150 1 0 decap_w0
xfeed_151 1 0 decap_w0
xfeed_152 1 0 decap_w0
xfeed_153 1 0 decap_w0
xfeed_154 1 0 decap_w0
xfeed_155 1 0 decap_w0
xfeed_156 1 0 decap_w0
xfeed_157 1 0 decap_w0
xfeed_158 1 0 decap_w0
xfeed_159 1 0 decap_w0
xfeed_30155 1 0 decap_w0
xfeed_30154 1 0 decap_w0
xfeed_30153 1 0 decap_w0
xfeed_30152 1 0 decap_w0
xfeed_30151 1 0 decap_w0
xfeed_30150 1 0 decap_w0
xfeed_12699 1 0 decap_w0
xfeed_12698 1 0 decap_w0
xfeed_12697 1 0 decap_w0
xfeed_12696 1 0 decap_w0
xfeed_12695 1 0 decap_w0
xfeed_12694 1 0 decap_w0
xfeed_12693 1 0 decap_w0
xfeed_12692 1 0 decap_w0
xfeed_12691 1 0 decap_w0
xfeed_12690 1 0 decap_w0
xfeed_7109 1 0 decap_w0
xfeed_7108 1 0 decap_w0
xfeed_7107 1 0 decap_w0
xfeed_7106 1 0 decap_w0
xfeed_7105 1 0 decap_w0
xfeed_7104 1 0 decap_w0
xfeed_7103 1 0 decap_w0
xfeed_7102 1 0 decap_w0
xfeed_7101 1 0 decap_w0
xfeed_7100 1 0 decap_w0
xfeed_6499 1 0 decap_w0
xfeed_6498 1 0 decap_w0
xfeed_6497 1 0 decap_w0
xfeed_6496 1 0 decap_w0
xfeed_6495 1 0 decap_w0
xfeed_6494 1 0 decap_w0
xfeed_6493 1 0 decap_w0
xfeed_6492 1 0 decap_w0
xfeed_6491 1 0 decap_w0
xfeed_6490 1 0 decap_w0
xfeed_5960 1 0 decap_w0
xfeed_2189 1 0 decap_w0
xfeed_2188 1 0 decap_w0
xfeed_2187 1 0 decap_w0
xfeed_2186 1 0 decap_w0
xfeed_2185 1 0 decap_w0
xfeed_2184 1 0 decap_w0
xfeed_2183 1 0 decap_w0
xfeed_2182 1 0 decap_w0
xfeed_2181 1 0 decap_w0
xfeed_2180 1 0 decap_w0
xfeed_1650 1 0 decap_w0
xfeed_1651 1 0 decap_w0
xfeed_1652 1 0 decap_w0
xfeed_1653 1 0 decap_w0
xfeed_1654 1 0 decap_w0
xfeed_1655 1 0 decap_w0
xfeed_1656 1 0 decap_w0
xfeed_1657 1 0 decap_w0
xfeed_1658 1 0 decap_w0
xfeed_1659 1 0 decap_w0
xfeed_30159 1 0 decap_w0
xfeed_30158 1 0 decap_w0
xfeed_30157 1 0 decap_w0
xfeed_30156 1 0 decap_w0
xfeed_28469 1 0 decap_w0
xfeed_28468 1 0 decap_w0
xfeed_28467 1 0 decap_w0
xfeed_28466 1 0 decap_w0
xfeed_28465 1 0 decap_w0
xfeed_28464 1 0 decap_w0
xfeed_28463 1 0 decap_w0
xfeed_28462 1 0 decap_w0
xfeed_28461 1 0 decap_w0
xfeed_28460 1 0 decap_w0
xfeed_27939 1 0 decap_w0
xfeed_27938 1 0 decap_w0
xfeed_27937 1 0 decap_w0
xfeed_27936 1 0 decap_w0
xfeed_27935 1 0 decap_w0
xfeed_27934 1 0 decap_w0
xfeed_27933 1 0 decap_w0
xfeed_27932 1 0 decap_w0
xfeed_27931 1 0 decap_w0
xfeed_27930 1 0 decap_w0
xfeed_24159 1 0 decap_w0
xfeed_24158 1 0 decap_w0
xfeed_24157 1 0 decap_w0
xfeed_24156 1 0 decap_w0
xfeed_24155 1 0 decap_w0
xfeed_24154 1 0 decap_w0
xfeed_24153 1 0 decap_w0
xfeed_24152 1 0 decap_w0
xfeed_24151 1 0 decap_w0
xfeed_24150 1 0 decap_w0
xfeed_23629 1 0 decap_w0
xfeed_23628 1 0 decap_w0
xfeed_23627 1 0 decap_w0
xfeed_23626 1 0 decap_w0
xfeed_23625 1 0 decap_w0
xfeed_23624 1 0 decap_w0
xfeed_23623 1 0 decap_w0
xfeed_23622 1 0 decap_w0
xfeed_23621 1 0 decap_w0
xfeed_23620 1 0 decap_w0
xfeed_18159 1 0 decap_w0
xfeed_18158 1 0 decap_w0
xfeed_18157 1 0 decap_w0
xfeed_18156 1 0 decap_w0
xfeed_18155 1 0 decap_w0
xfeed_18154 1 0 decap_w0
xfeed_18153 1 0 decap_w0
xfeed_18152 1 0 decap_w0
xfeed_18150 1 0 decap_w0
xfeed_17626 1 0 decap_w0
xfeed_17625 1 0 decap_w0
xfeed_17624 1 0 decap_w0
xfeed_17623 1 0 tie
xfeed_17622 1 0 decap_w0
xfeed_17621 1 0 decap_w0
xfeed_17620 1 0 decap_w0
xfeed_13319 1 0 decap_w0
xfeed_13318 1 0 decap_w0
xfeed_13317 1 0 decap_w0
xfeed_13316 1 0 decap_w0
xfeed_13315 1 0 decap_w0
xfeed_13314 1 0 decap_w0
xfeed_13313 1 0 decap_w0
xfeed_13312 1 0 decap_w0
xfeed_13311 1 0 decap_w0
xfeed_13310 1 0 decap_w0
xfeed_5969 1 0 decap_w0
xfeed_5968 1 0 decap_w0
xfeed_5967 1 0 decap_w0
xfeed_5966 1 0 decap_w0
xfeed_5965 1 0 decap_w0
xfeed_5964 1 0 decap_w0
xfeed_5963 1 0 decap_w0
xfeed_5962 1 0 decap_w0
xfeed_5961 1 0 decap_w0
xfeed_160 1 0 decap_w0
xfeed_161 1 0 decap_w0
xfeed_162 1 0 decap_w0
xfeed_163 1 0 decap_w0
xfeed_164 1 0 decap_w0
xfeed_165 1 0 decap_w0
xfeed_166 1 0 decap_w0
xfeed_167 1 0 decap_w0
xfeed_168 1 0 decap_w0
xfeed_169 1 0 decap_w0
xfeed_30162 1 0 decap_w0
xfeed_30161 1 0 decap_w0
xfeed_30160 1 0 decap_w0
xfeed_17629 1 0 decap_w0
xfeed_17628 1 0 decap_w0
xfeed_17627 1 0 decap_w0
xfeed_7119 1 0 decap_w0
xfeed_7118 1 0 decap_w0
xfeed_7117 1 0 decap_w0
xfeed_7116 1 0 decap_w0
xfeed_7115 1 0 decap_w0
xfeed_7114 1 0 decap_w0
xfeed_7113 1 0 decap_w0
xfeed_7112 1 0 decap_w0
xfeed_7111 1 0 decap_w0
xfeed_7110 1 0 decap_w0
xfeed_2199 1 0 decap_w0
xfeed_2198 1 0 decap_w0
xfeed_2197 1 0 decap_w0
xfeed_2196 1 0 decap_w0
xfeed_2195 1 0 decap_w0
xfeed_2194 1 0 decap_w0
xfeed_2193 1 0 decap_w0
xfeed_2192 1 0 decap_w0
xfeed_2191 1 0 decap_w0
xfeed_2190 1 0 decap_w0
xspare_feed_200 1 0 tie
xspare_feed_201 1 0 decap_w0
xspare_feed_202 1 0 tie
xspare_feed_203 1 0 tie
xspare_feed_204 1 0 decap_w0
xspare_feed_205 1 0 tie
xspare_feed_206 1 0 tie
xspare_feed_207 1 0 decap_w0
xspare_feed_208 1 0 tie
xspare_feed_209 1 0 tie
xfeed_1660 1 0 decap_w0
xfeed_1661 1 0 decap_w0
xfeed_1662 1 0 decap_w0
xfeed_1663 1 0 decap_w0
xfeed_1664 1 0 decap_w0
xfeed_1665 1 0 decap_w0
xfeed_1666 1 0 decap_w0
xfeed_1667 1 0 decap_w0
xfeed_30169 1 0 decap_w0
xfeed_30168 1 0 decap_w0
xfeed_30167 1 0 decap_w0
xfeed_30166 1 0 decap_w0
xfeed_30165 1 0 decap_w0
xfeed_30164 1 0 decap_w0
xfeed_30163 1 0 decap_w0
xfeed_28479 1 0 decap_w0
xfeed_28478 1 0 decap_w0
xfeed_28477 1 0 decap_w0
xfeed_28476 1 0 decap_w0
xfeed_28475 1 0 decap_w0
xfeed_28474 1 0 decap_w0
xfeed_28473 1 0 decap_w0
xfeed_28472 1 0 decap_w0
xfeed_28471 1 0 decap_w0
xfeed_28470 1 0 decap_w0
xfeed_27949 1 0 decap_w0
xfeed_27948 1 0 decap_w0
xfeed_27947 1 0 decap_w0
xfeed_27946 1 0 decap_w0
xfeed_27945 1 0 decap_w0
xfeed_27944 1 0 decap_w0
xfeed_27943 1 0 decap_w0
xfeed_27942 1 0 decap_w0
xfeed_27941 1 0 decap_w0
xfeed_27940 1 0 decap_w0
xfeed_24169 1 0 decap_w0
xfeed_24168 1 0 decap_w0
xfeed_24167 1 0 decap_w0
xfeed_24166 1 0 decap_w0
xfeed_24165 1 0 decap_w0
xfeed_24164 1 0 decap_w0
xfeed_24163 1 0 decap_w0
xfeed_24162 1 0 decap_w0
xfeed_24161 1 0 decap_w0
xfeed_24160 1 0 decap_w0
xfeed_23639 1 0 decap_w0
xfeed_23638 1 0 decap_w0
xfeed_23637 1 0 decap_w0
xfeed_23636 1 0 decap_w0
xfeed_23635 1 0 decap_w0
xfeed_23634 1 0 decap_w0
xfeed_23633 1 0 decap_w0
xfeed_23632 1 0 decap_w0
xfeed_23631 1 0 decap_w0
xfeed_23630 1 0 decap_w0
xfeed_18169 1 0 decap_w0
xfeed_18168 1 0 decap_w0
xfeed_18167 1 0 decap_w0
xfeed_18166 1 0 decap_w0
xfeed_18165 1 0 decap_w0
xfeed_18164 1 0 decap_w0
xfeed_18163 1 0 decap_w0
xfeed_18162 1 0 decap_w0
xfeed_18161 1 0 decap_w0
xfeed_18160 1 0 decap_w0
xfeed_17633 1 0 decap_w0
xfeed_17632 1 0 decap_w0
xfeed_17631 1 0 decap_w0
xfeed_17630 1 0 decap_w0
xfeed_13329 1 0 decap_w0
xfeed_13328 1 0 decap_w0
xfeed_13327 1 0 decap_w0
xfeed_13326 1 0 decap_w0
xfeed_13325 1 0 decap_w0
xfeed_13324 1 0 decap_w0
xfeed_13323 1 0 decap_w0
xfeed_13322 1 0 decap_w0
xfeed_13321 1 0 decap_w0
xfeed_13320 1 0 decap_w0
xfeed_5979 1 0 decap_w0
xfeed_5978 1 0 decap_w0
xfeed_5977 1 0 decap_w0
xfeed_5976 1 0 decap_w0
xfeed_5975 1 0 decap_w0
xfeed_5974 1 0 decap_w0
xfeed_5973 1 0 decap_w0
xfeed_5972 1 0 decap_w0
xfeed_5971 1 0 decap_w0
xfeed_5970 1 0 decap_w0
xfeed_170 1 0 decap_w0
xfeed_171 1 0 decap_w0
xfeed_172 1 0 decap_w0
xfeed_173 1 0 decap_w0
xfeed_174 1 0 decap_w0
xfeed_175 1 0 decap_w0
xfeed_176 1 0 decap_w0
xfeed_177 1 0 decap_w0
xfeed_178 1 0 decap_w0
xfeed_179 1 0 decap_w0
xfeed_1668 1 0 decap_w0
xfeed_1669 1 0 decap_w0
xfeed_17639 1 0 decap_w0
xfeed_17638 1 0 decap_w0
xfeed_17637 1 0 decap_w0
xfeed_17636 1 0 decap_w0
xfeed_17635 1 0 decap_w0
xfeed_17634 1 0 decap_w0
xfeed_7129 1 0 decap_w0
xfeed_7128 1 0 decap_w0
xfeed_7127 1 0 decap_w0
xfeed_7126 1 0 decap_w0
xfeed_7125 1 0 decap_w0
xfeed_7124 1 0 decap_w0
xfeed_7123 1 0 decap_w0
xfeed_7122 1 0 decap_w0
xfeed_7121 1 0 decap_w0
xfeed_7120 1 0 decap_w0
xspare_feed_210 1 0 decap_w0
xspare_feed_211 1 0 tie
xspare_feed_212 1 0 tie
xspare_feed_213 1 0 decap_w0
xspare_feed_214 1 0 tie
xspare_feed_215 1 0 tie
xspare_feed_216 1 0 decap_w0
xspare_feed_217 1 0 tie
xspare_feed_218 1 0 tie
xspare_feed_219 1 0 decap_w0
xfeed_1670 1 0 decap_w0
xfeed_1671 1 0 decap_w0
xfeed_1672 1 0 decap_w0
xfeed_1673 1 0 decap_w0
xfeed_1674 1 0 decap_w0
xfeed_30179 1 0 decap_w0
xfeed_30178 1 0 decap_w0
xfeed_30177 1 0 decap_w0
xfeed_30176 1 0 decap_w0
xfeed_30175 1 0 decap_w0
xfeed_30174 1 0 decap_w0
xfeed_30173 1 0 decap_w0
xfeed_30172 1 0 decap_w0
xfeed_30171 1 0 decap_w0
xfeed_30170 1 0 decap_w0
xfeed_28489 1 0 decap_w0
xfeed_28488 1 0 decap_w0
xfeed_28487 1 0 decap_w0
xfeed_28486 1 0 decap_w0
xfeed_28485 1 0 decap_w0
xfeed_28484 1 0 decap_w0
xfeed_28483 1 0 decap_w0
xfeed_28482 1 0 decap_w0
xfeed_28481 1 0 decap_w0
xfeed_28480 1 0 decap_w0
xfeed_27959 1 0 decap_w0
xfeed_27958 1 0 decap_w0
xfeed_27957 1 0 decap_w0
xfeed_27956 1 0 decap_w0
xfeed_27955 1 0 decap_w0
xfeed_27954 1 0 decap_w0
xfeed_27953 1 0 decap_w0
xfeed_27952 1 0 decap_w0
xfeed_27951 1 0 decap_w0
xfeed_27950 1 0 decap_w0
xfeed_24179 1 0 decap_w0
xfeed_24178 1 0 decap_w0
xfeed_24177 1 0 decap_w0
xfeed_24176 1 0 decap_w0
xfeed_24175 1 0 decap_w0
xfeed_24174 1 0 decap_w0
xfeed_24173 1 0 decap_w0
xfeed_24172 1 0 decap_w0
xfeed_24171 1 0 decap_w0
xfeed_24170 1 0 decap_w0
xfeed_23649 1 0 decap_w0
xfeed_23648 1 0 decap_w0
xfeed_23647 1 0 decap_w0
xfeed_23646 1 0 decap_w0
xfeed_23645 1 0 decap_w0
xfeed_23644 1 0 decap_w0
xfeed_23643 1 0 decap_w0
xfeed_23642 1 0 decap_w0
xfeed_23641 1 0 decap_w0
xfeed_23640 1 0 decap_w0
xfeed_18179 1 0 decap_w0
xfeed_18178 1 0 decap_w0
xfeed_18177 1 0 decap_w0
xfeed_18176 1 0 decap_w0
xfeed_18175 1 0 decap_w0
xfeed_18174 1 0 decap_w0
xfeed_18173 1 0 decap_w0
xfeed_18172 1 0 decap_w0
xfeed_18171 1 0 decap_w0
xfeed_18170 1 0 decap_w0
xfeed_17640 1 0 decap_w0
xfeed_13339 1 0 decap_w0
xfeed_13338 1 0 decap_w0
xfeed_13337 1 0 decap_w0
xfeed_13336 1 0 decap_w0
xfeed_13335 1 0 decap_w0
xfeed_13334 1 0 decap_w0
xfeed_13333 1 0 decap_w0
xfeed_13332 1 0 decap_w0
xfeed_13331 1 0 decap_w0
xfeed_13330 1 0 decap_w0
xfeed_12801 1 0 decap_w0
xfeed_12800 1 0 decap_w0
xfeed_5989 1 0 decap_w0
xfeed_5988 1 0 decap_w0
xfeed_5987 1 0 decap_w0
xfeed_5986 1 0 decap_w0
xfeed_5985 1 0 decap_w0
xfeed_5984 1 0 decap_w0
xfeed_5983 1 0 decap_w0
xfeed_5982 1 0 decap_w0
xfeed_5981 1 0 decap_w0
xfeed_5980 1 0 decap_w0
xfeed_180 1 0 decap_w0
xfeed_181 1 0 decap_w0
xfeed_182 1 0 decap_w0
xfeed_183 1 0 decap_w0
xfeed_184 1 0 decap_w0
xfeed_185 1 0 decap_w0
xfeed_186 1 0 decap_w0
xfeed_187 1 0 decap_w0
xfeed_188 1 0 decap_w0
xfeed_189 1 0 decap_w0
xfeed_1675 1 0 decap_w0
xfeed_1676 1 0 decap_w0
xfeed_1677 1 0 decap_w0
xfeed_1678 1 0 decap_w0
xfeed_1679 1 0 decap_w0
xfeed_17649 1 0 decap_w0
xfeed_17648 1 0 decap_w0
xfeed_17647 1 0 decap_w0
xfeed_17646 1 0 decap_w0
xfeed_17645 1 0 decap_w0
xfeed_17644 1 0 decap_w0
xfeed_17643 1 0 decap_w0
xfeed_17642 1 0 decap_w0
xfeed_17641 1 0 decap_w0
xfeed_12809 1 0 decap_w0
xfeed_12808 1 0 decap_w0
xfeed_12807 1 0 decap_w0
xfeed_12806 1 0 decap_w0
xfeed_12805 1 0 decap_w0
xfeed_12804 1 0 decap_w0
xfeed_12803 1 0 decap_w0
xfeed_12802 1 0 decap_w0
xfeed_7139 1 0 decap_w0
xfeed_7138 1 0 decap_w0
xfeed_7137 1 0 decap_w0
xfeed_7136 1 0 decap_w0
xfeed_7135 1 0 tie
xfeed_7134 1 0 decap_w0
xfeed_7133 1 0 decap_w0
xfeed_7132 1 0 decap_w0
xfeed_7131 1 0 decap_w0
xfeed_7130 1 0 decap_w0
xfeed_6609 1 0 decap_w0
xfeed_6608 1 0 decap_w0
xfeed_6607 1 0 decap_w0
xfeed_6606 1 0 decap_w0
xfeed_6605 1 0 decap_w0
xfeed_6604 1 0 decap_w0
xfeed_6603 1 0 decap_w0
xfeed_6602 1 0 decap_w0
xfeed_6601 1 0 decap_w0
xfeed_6600 1 0 decap_w0
xspare_feed_220 1 0 tie
xspare_feed_221 1 0 tie
xspare_feed_222 1 0 decap_w0
xspare_feed_223 1 0 tie
xspare_feed_224 1 0 tie
xspare_feed_225 1 0 decap_w0
xspare_feed_226 1 0 tie
xspare_feed_227 1 0 tie
xspare_feed_228 1 0 decap_w0
xspare_feed_229 1 0 tie
xfeed_1680 1 0 decap_w0
xfeed_1681 1 0 decap_w0
xfeed_30189 1 0 decap_w0
xfeed_30188 1 0 decap_w0
xfeed_30187 1 0 decap_w0
xfeed_30186 1 0 decap_w0
xfeed_30185 1 0 decap_w0
xfeed_30184 1 0 decap_w0
xfeed_30183 1 0 decap_w0
xfeed_30182 1 0 decap_w0
xfeed_30181 1 0 decap_w0
xfeed_30180 1 0 decap_w0
xfeed_29109 1 0 decap_w0
xfeed_29108 1 0 decap_w0
xfeed_29107 1 0 decap_w0
xfeed_29106 1 0 decap_w0
xfeed_29105 1 0 decap_w0
xfeed_29104 1 0 decap_w0
xfeed_29103 1 0 decap_w0
xfeed_29102 1 0 decap_w0
xfeed_29101 1 0 decap_w0
xfeed_29100 1 0 decap_w0
xfeed_28499 1 0 decap_w0
xfeed_28498 1 0 decap_w0
xfeed_28497 1 0 decap_w0
xfeed_28496 1 0 decap_w0
xfeed_28495 1 0 decap_w0
xfeed_28494 1 0 decap_w0
xfeed_28493 1 0 decap_w0
xfeed_28492 1 0 decap_w0
xfeed_28491 1 0 decap_w0
xfeed_28490 1 0 decap_w0
xfeed_27969 1 0 decap_w0
xfeed_27968 1 0 decap_w0
xfeed_27967 1 0 decap_w0
xfeed_27966 1 0 decap_w0
xfeed_27965 1 0 decap_w0
xfeed_27964 1 0 decap_w0
xfeed_27963 1 0 decap_w0
xfeed_27962 1 0 decap_w0
xfeed_27961 1 0 decap_w0
xfeed_27960 1 0 decap_w0
xfeed_24189 1 0 decap_w0
xfeed_24188 1 0 decap_w0
xfeed_24187 1 0 decap_w0
xfeed_24186 1 0 decap_w0
xfeed_24185 1 0 decap_w0
xfeed_24184 1 0 decap_w0
xfeed_24183 1 0 decap_w0
xfeed_24182 1 0 decap_w0
xfeed_24181 1 0 decap_w0
xfeed_24180 1 0 decap_w0
xfeed_23659 1 0 decap_w0
xfeed_23658 1 0 tie
xfeed_23657 1 0 decap_w0
xfeed_23656 1 0 decap_w0
xfeed_23655 1 0 decap_w0
xfeed_23654 1 0 decap_w0
xfeed_23653 1 0 decap_w0
xfeed_23652 1 0 decap_w0
xfeed_23651 1 0 decap_w0
xfeed_23650 1 0 decap_w0
xfeed_18186 1 0 decap_w0
xfeed_18185 1 0 decap_w0
xfeed_18184 1 0 decap_w0
xfeed_18183 1 0 decap_w0
xfeed_18182 1 0 decap_w0
xfeed_18181 1 0 decap_w0
xfeed_18180 1 0 decap_w0
xfeed_13347 1 0 decap_w0
xfeed_13346 1 0 decap_w0
xfeed_13345 1 0 decap_w0
xfeed_13344 1 0 decap_w0
xfeed_13343 1 0 decap_w0
xfeed_13342 1 0 decap_w0
xfeed_13341 1 0 decap_w0
xfeed_13340 1 0 decap_w0
xfeed_5999 1 0 decap_w0
xfeed_5998 1 0 decap_w0
xfeed_5997 1 0 decap_w0
xfeed_5996 1 0 decap_w0
xfeed_5995 1 0 decap_w0
xfeed_5994 1 0 decap_w0
xfeed_5993 1 0 decap_w0
xfeed_5992 1 0 decap_w0
xfeed_5991 1 0 decap_w0
xfeed_5990 1 0 decap_w0
xfeed_190 1 0 decap_w0
xfeed_191 1 0 decap_w0
xfeed_192 1 0 decap_w0
xfeed_193 1 0 decap_w0
xfeed_194 1 0 decap_w0
xfeed_195 1 0 decap_w0
xfeed_196 1 0 decap_w0
xfeed_197 1 0 decap_w0
xfeed_198 1 0 decap_w0
xfeed_199 1 0 decap_w0
xfeed_1682 1 0 decap_w0
xfeed_1683 1 0 decap_w0
xfeed_1684 1 0 decap_w0
xfeed_1685 1 0 decap_w0
xfeed_1686 1 0 decap_w0
xfeed_1687 1 0 decap_w0
xfeed_1688 1 0 decap_w0
xfeed_1689 1 0 decap_w0
xfeed_18188 1 0 decap_w0
xfeed_18187 1 0 decap_w0
xfeed_17659 1 0 decap_w0
xfeed_17658 1 0 decap_w0
xfeed_17657 1 0 decap_w0
xfeed_17656 1 0 decap_w0
xfeed_17655 1 0 decap_w0
xfeed_17654 1 0 decap_w0
xfeed_17653 1 0 decap_w0
xfeed_17652 1 0 decap_w0
xfeed_17651 1 0 decap_w0
xfeed_17650 1 0 decap_w0
xfeed_13349 1 0 decap_w0
xfeed_13348 1 0 decap_w0
xfeed_12819 1 0 decap_w0
xfeed_12818 1 0 decap_w0
xfeed_12817 1 0 decap_w0
xfeed_12816 1 0 decap_w0
xfeed_12815 1 0 decap_w0
xfeed_12814 1 0 decap_w0
xfeed_12813 1 0 decap_w0
xfeed_12812 1 0 decap_w0
xfeed_12811 1 0 decap_w0
xfeed_12810 1 0 decap_w0
xfeed_7149 1 0 decap_w0
xfeed_7148 1 0 decap_w0
xfeed_7147 1 0 decap_w0
xfeed_7146 1 0 decap_w0
xfeed_7145 1 0 decap_w0
xfeed_7144 1 0 decap_w0
xfeed_7143 1 0 decap_w0
xfeed_7142 1 0 decap_w0
xfeed_7141 1 0 decap_w0
xfeed_7140 1 0 decap_w0
xfeed_6619 1 0 decap_w0
xfeed_6618 1 0 decap_w0
xfeed_6617 1 0 decap_w0
xfeed_6616 1 0 decap_w0
xfeed_6615 1 0 decap_w0
xfeed_6614 1 0 decap_w0
xfeed_6613 1 0 decap_w0
xfeed_6612 1 0 decap_w0
xfeed_6611 1 0 decap_w0
xfeed_6610 1 0 decap_w0
xfeed_2309 1 0 decap_w0
xfeed_2308 1 0 decap_w0
xfeed_2307 1 0 decap_w0
xfeed_2306 1 0 decap_w0
xfeed_2305 1 0 decap_w0
xfeed_2304 1 0 decap_w0
xfeed_2303 1 0 decap_w0
xfeed_2302 1 0 decap_w0
xfeed_2301 1 0 decap_w0
xfeed_2300 1 0 decap_w0
xspare_feed_230 1 0 tie
xspare_feed_231 1 0 decap_w0
xspare_feed_232 1 0 tie
xspare_feed_233 1 0 tie
xspare_feed_234 1 0 decap_w0
xspare_feed_235 1 0 tie
xspare_feed_236 1 0 tie
xspare_feed_237 1 0 decap_w0
xspare_feed_238 1 0 tie
xspare_feed_239 1 0 tie
xfeed_30199 1 0 decap_w0
xfeed_30198 1 0 decap_w0
xfeed_30197 1 0 decap_w0
xfeed_30196 1 0 decap_w0
xfeed_30195 1 0 decap_w0
xfeed_30194 1 0 decap_w0
xfeed_30193 1 0 decap_w0
xfeed_30192 1 0 decap_w0
xfeed_30191 1 0 decap_w0
xfeed_30190 1 0 decap_w0
xfeed_29119 1 0 decap_w0
xfeed_29118 1 0 decap_w0
xfeed_29117 1 0 decap_w0
xfeed_29116 1 0 decap_w0
xfeed_29115 1 0 decap_w0
xfeed_29114 1 0 decap_w0
xfeed_29113 1 0 decap_w0
xfeed_29112 1 0 decap_w0
xfeed_29111 1 0 decap_w0
xfeed_29110 1 0 decap_w0
xfeed_27979 1 0 decap_w0
xfeed_27978 1 0 decap_w0
xfeed_27977 1 0 decap_w0
xfeed_27976 1 0 decap_w0
xfeed_27975 1 0 decap_w0
xfeed_27974 1 0 decap_w0
xfeed_27973 1 0 decap_w0
xfeed_27972 1 0 decap_w0
xfeed_27971 1 0 decap_w0
xfeed_27970 1 0 decap_w0
xfeed_24199 1 0 decap_w0
xfeed_24198 1 0 decap_w0
xfeed_24197 1 0 decap_w0
xfeed_24196 1 0 decap_w0
xfeed_24195 1 0 decap_w0
xfeed_24194 1 0 decap_w0
xfeed_24193 1 0 decap_w0
xfeed_24192 1 0 decap_w0
xfeed_24191 1 0 decap_w0
xfeed_24190 1 0 decap_w0
xfeed_23669 1 0 decap_w0
xfeed_23668 1 0 decap_w0
xfeed_23667 1 0 decap_w0
xfeed_23666 1 0 decap_w0
xfeed_23665 1 0 decap_w0
xfeed_23664 1 0 decap_w0
xfeed_23663 1 0 decap_w0
xfeed_23662 1 0 decap_w0
xfeed_23661 1 0 decap_w0
xfeed_23660 1 0 decap_w0
xfeed_18193 1 0 decap_w0
xfeed_18192 1 0 decap_w0
xfeed_18191 1 0 decap_w0
xfeed_18190 1 0 decap_w0
xfeed_13354 1 0 decap_w0
xfeed_13353 1 0 decap_w0
xfeed_13352 1 0 decap_w0
xfeed_13351 1 0 decap_w0
xfeed_13350 1 0 decap_w0
xfeed_1690 1 0 decap_w0
xfeed_1691 1 0 decap_w0
xfeed_1692 1 0 decap_w0
xfeed_1693 1 0 decap_w0
xfeed_1694 1 0 decap_w0
xfeed_1695 1 0 decap_w0
xfeed_1696 1 0 decap_w0
xfeed_1697 1 0 decap_w0
xfeed_1698 1 0 decap_w0
xfeed_1699 1 0 decap_w0
xfeed_18199 1 0 decap_w0
xfeed_18198 1 0 decap_w0
xfeed_18197 1 0 decap_w0
xfeed_18196 1 0 decap_w0
xfeed_18195 1 0 decap_w0
xfeed_18194 1 0 decap_w0
xfeed_17669 1 0 decap_w0
xfeed_17668 1 0 decap_w0
xfeed_17667 1 0 decap_w0
xfeed_17666 1 0 decap_w0
xfeed_17665 1 0 decap_w0
xfeed_17664 1 0 decap_w0
xfeed_17663 1 0 decap_w0
xfeed_17662 1 0 decap_w0
xfeed_17661 1 0 decap_w0
xfeed_17660 1 0 decap_w0
xfeed_13359 1 0 decap_w0
xfeed_13358 1 0 decap_w0
xfeed_13357 1 0 decap_w0
xfeed_13356 1 0 decap_w0
xfeed_13355 1 0 decap_w0
xfeed_12829 1 0 decap_w0
xfeed_12828 1 0 decap_w0
xfeed_12827 1 0 decap_w0
xfeed_12826 1 0 decap_w0
xfeed_12825 1 0 decap_w0
xfeed_12824 1 0 decap_w0
xfeed_12823 1 0 decap_w0
xfeed_12822 1 0 decap_w0
xfeed_12821 1 0 decap_w0
xfeed_12820 1 0 decap_w0
xfeed_7159 1 0 decap_w0
xfeed_7158 1 0 decap_w0
xfeed_7157 1 0 decap_w0
xfeed_7156 1 0 decap_w0
xfeed_7155 1 0 decap_w0
xfeed_7154 1 0 decap_w0
xfeed_7153 1 0 decap_w0
xfeed_7152 1 0 decap_w0
xfeed_7151 1 0 decap_w0
xfeed_7150 1 0 decap_w0
xfeed_6629 1 0 decap_w0
xfeed_6628 1 0 decap_w0
xfeed_6627 1 0 decap_w0
xfeed_6626 1 0 decap_w0
xfeed_6625 1 0 decap_w0
xfeed_6624 1 0 decap_w0
xfeed_6623 1 0 decap_w0
xfeed_6622 1 0 decap_w0
xfeed_6621 1 0 decap_w0
xfeed_6620 1 0 decap_w0
xfeed_2319 1 0 decap_w0
xfeed_2318 1 0 decap_w0
xfeed_2317 1 0 decap_w0
xfeed_2316 1 0 decap_w0
xfeed_2315 1 0 decap_w0
xfeed_2314 1 0 decap_w0
xfeed_2313 1 0 decap_w0
xfeed_2312 1 0 decap_w0
xfeed_2311 1 0 decap_w0
xfeed_2310 1 0 decap_w0
xspare_feed_240 1 0 decap_w0
xspare_feed_241 1 0 tie
xspare_feed_242 1 0 tie
xspare_feed_243 1 0 decap_w0
xspare_feed_244 1 0 tie
xspare_feed_245 1 0 tie
xspare_feed_246 1 0 decap_w0
xfeed_29129 1 0 decap_w0
xfeed_29128 1 0 decap_w0
xfeed_29127 1 0 decap_w0
xfeed_29126 1 0 decap_w0
xfeed_29125 1 0 decap_w0
xfeed_29124 1 0 decap_w0
xfeed_29123 1 0 decap_w0
xfeed_29122 1 0 decap_w0
xfeed_29121 1 0 decap_w0
xfeed_29120 1 0 decap_w0
xfeed_27988 1 0 decap_w0
xfeed_27987 1 0 decap_w0
xfeed_27986 1 0 decap_w0
xfeed_27985 1 0 decap_w0
xfeed_27984 1 0 decap_w0
xfeed_27983 1 0 decap_w0
xfeed_27982 1 0 decap_w0
xfeed_27981 1 0 decap_w0
xfeed_27980 1 0 decap_w0
xfeed_23679 1 0 decap_w0
xfeed_23678 1 0 decap_w0
xfeed_23677 1 0 decap_w0
xfeed_23676 1 0 decap_w0
xfeed_23675 1 0 decap_w0
xfeed_23674 1 0 decap_w0
xfeed_23673 1 0 decap_w0
xfeed_23672 1 0 decap_w0
xfeed_23671 1 0 decap_w0
xfeed_23670 1 0 decap_w0
xfeed_13361 1 0 decap_w0
xfeed_13360 1 0 decap_w0
xspare_feed_247 1 0 tie
xspare_feed_248 1 0 tie
xspare_feed_249 1 0 decap_w0
xfeed_27989 1 0 decap_w0
xfeed_17679 1 0 decap_w0
xfeed_17678 1 0 decap_w0
xfeed_17677 1 0 decap_w0
xfeed_17676 1 0 decap_w0
xfeed_17675 1 0 decap_w0
xfeed_17674 1 0 decap_w0
xfeed_17673 1 0 decap_w0
xfeed_17672 1 0 decap_w0
xfeed_17671 1 0 decap_w0
xfeed_17670 1 0 decap_w0
xfeed_13369 1 0 decap_w0
xfeed_13368 1 0 decap_w0
xfeed_13367 1 0 decap_w0
xfeed_13366 1 0 decap_w0
xfeed_13365 1 0 decap_w0
xfeed_13364 1 0 decap_w0
xfeed_13363 1 0 decap_w0
xfeed_13362 1 0 decap_w0
xfeed_12839 1 0 decap_w0
xfeed_12838 1 0 decap_w0
xfeed_12837 1 0 decap_w0
xfeed_12836 1 0 decap_w0
xfeed_12835 1 0 decap_w0
xfeed_12834 1 0 decap_w0
xfeed_12833 1 0 decap_w0
xfeed_12832 1 0 decap_w0
xfeed_12831 1 0 decap_w0
xfeed_12830 1 0 decap_w0
xfeed_7169 1 0 decap_w0
xfeed_7168 1 0 decap_w0
xfeed_7167 1 0 decap_w0
xfeed_7166 1 0 decap_w0
xfeed_7165 1 0 decap_w0
xfeed_7164 1 0 decap_w0
xfeed_7163 1 0 decap_w0
xfeed_7162 1 0 decap_w0
xfeed_7161 1 0 decap_w0
xfeed_7160 1 0 decap_w0
xfeed_6639 1 0 decap_w0
xfeed_6638 1 0 decap_w0
xfeed_6637 1 0 decap_w0
xfeed_6636 1 0 decap_w0
xfeed_6635 1 0 decap_w0
xfeed_6634 1 0 decap_w0
xfeed_6633 1 0 decap_w0
xfeed_6632 1 0 decap_w0
xfeed_6631 1 0 decap_w0
xfeed_6630 1 0 decap_w0
xfeed_2329 1 0 decap_w0
xfeed_2328 1 0 decap_w0
xfeed_2327 1 0 decap_w0
xfeed_2326 1 0 decap_w0
xfeed_2325 1 0 decap_w0
xfeed_2324 1 0 decap_w0
xfeed_2323 1 0 decap_w0
xfeed_2322 1 0 decap_w0
xfeed_2321 1 0 decap_w0
xfeed_2320 1 0 decap_w0
xspare_feed_250 1 0 tie
xspare_feed_251 1 0 tie
xspare_feed_252 1 0 decap_w0
xspare_feed_253 1 0 tie
xfeed_29139 1 0 decap_w0
xfeed_29138 1 0 decap_w0
xfeed_29137 1 0 decap_w0
xfeed_29136 1 0 decap_w0
xfeed_29135 1 0 decap_w0
xfeed_29134 1 0 decap_w0
xfeed_29133 1 0 decap_w0
xfeed_29132 1 0 decap_w0
xfeed_29131 1 0 decap_w0
xfeed_29130 1 0 decap_w0
xfeed_28609 1 0 decap_w0
xfeed_28608 1 0 decap_w0
xfeed_28607 1 0 decap_w0
xfeed_28606 1 0 decap_w0
xfeed_28605 1 0 decap_w0
xfeed_28604 1 0 decap_w0
xfeed_28603 1 0 decap_w0
xfeed_28602 1 0 decap_w0
xfeed_28601 1 0 decap_w0
xfeed_28600 1 0 decap_w0
xfeed_27995 1 0 decap_w0
xfeed_27994 1 0 decap_w0
xfeed_27993 1 0 decap_w0
xfeed_27992 1 0 decap_w0
xfeed_27991 1 0 decap_w0
xfeed_27990 1 0 decap_w0
xfeed_23689 1 0 decap_w0
xfeed_23688 1 0 decap_w0
xfeed_23687 1 0 decap_w0
xfeed_23686 1 0 decap_w0
xfeed_23685 1 0 decap_w0
xfeed_23684 1 0 decap_w0
xfeed_23683 1 0 decap_w0
xfeed_23682 1 0 decap_w0
xfeed_23681 1 0 decap_w0
xfeed_23680 1 0 decap_w0
xfeed_309 1 0 decap_w0
xfeed_308 1 0 decap_w0
xfeed_307 1 0 decap_w0
xfeed_306 1 0 decap_w0
xfeed_305 1 0 decap_w0
xfeed_304 1 0 decap_w0
xfeed_303 1 0 decap_w0
xfeed_302 1 0 decap_w0
xfeed_301 1 0 decap_w0
xfeed_300 1 0 decap_w0
xspare_feed_254 1 0 tie
xspare_feed_255 1 0 decap_w0
xspare_feed_256 1 0 tie
xspare_feed_257 1 0 tie
xspare_feed_258 1 0 decap_w0
xspare_feed_259 1 0 tie
xfeed_30302 1 0 decap_w0
xfeed_30301 1 0 decap_w0
xfeed_30300 1 0 decap_w0
xfeed_27999 1 0 decap_w0
xfeed_27998 1 0 decap_w0
xfeed_27997 1 0 decap_w0
xfeed_27996 1 0 decap_w0
xfeed_17689 1 0 decap_w0
xfeed_17688 1 0 decap_w0
xfeed_17687 1 0 decap_w0
xfeed_17686 1 0 decap_w0
xfeed_17685 1 0 decap_w0
xfeed_17684 1 0 decap_w0
xfeed_17683 1 0 decap_w0
xfeed_17682 1 0 decap_w0
xfeed_17681 1 0 decap_w0
xfeed_17680 1 0 decap_w0
xfeed_13379 1 0 decap_w0
xfeed_13378 1 0 decap_w0
xfeed_13377 1 0 decap_w0
xfeed_13376 1 0 decap_w0
xfeed_13375 1 0 decap_w0
xfeed_13374 1 0 decap_w0
xfeed_13373 1 0 decap_w0
xfeed_13372 1 0 decap_w0
xfeed_13371 1 0 decap_w0
xfeed_13370 1 0 decap_w0
xfeed_12849 1 0 decap_w0
xfeed_12848 1 0 decap_w0
xfeed_12847 1 0 decap_w0
xfeed_12846 1 0 decap_w0
xfeed_12845 1 0 decap_w0
xfeed_12844 1 0 decap_w0
xfeed_12843 1 0 decap_w0
xfeed_12842 1 0 decap_w0
xfeed_12841 1 0 decap_w0
xfeed_12840 1 0 decap_w0
xfeed_7179 1 0 decap_w0
xfeed_7178 1 0 decap_w0
xfeed_7177 1 0 decap_w0
xfeed_7176 1 0 decap_w0
xfeed_7175 1 0 decap_w0
xfeed_7174 1 0 decap_w0
xfeed_7173 1 0 decap_w0
xfeed_7172 1 0 decap_w0
xfeed_7171 1 0 decap_w0
xfeed_7170 1 0 decap_w0
xfeed_6646 1 0 decap_w0
xfeed_6645 1 0 decap_w0
xfeed_6644 1 0 decap_w0
xfeed_6643 1 0 decap_w0
xfeed_6642 1 0 decap_w0
xfeed_6641 1 0 decap_w0
xfeed_6640 1 0 decap_w0
xfeed_2339 1 0 decap_w0
xfeed_2338 1 0 decap_w0
xfeed_2337 1 0 decap_w0
xfeed_2336 1 0 decap_w0
xfeed_2335 1 0 decap_w0
xfeed_2334 1 0 decap_w0
xfeed_2333 1 0 decap_w0
xfeed_2332 1 0 decap_w0
xfeed_2331 1 0 decap_w0
xfeed_2330 1 0 decap_w0
xspare_feed_260 1 0 tie
xfeed_1800 1 0 decap_w0
xfeed_1801 1 0 decap_w0
xfeed_1802 1 0 decap_w0
xfeed_1803 1 0 decap_w0
xfeed_1804 1 0 decap_w0
xfeed_1805 1 0 decap_w0
xfeed_1806 1 0 decap_w0
xfeed_1807 1 0 decap_w0
xfeed_30309 1 0 decap_w0
xfeed_30308 1 0 decap_w0
xfeed_30307 1 0 decap_w0
xfeed_30306 1 0 decap_w0
xfeed_30305 1 0 decap_w0
xfeed_30304 1 0 decap_w0
xfeed_30303 1 0 decap_w0
xfeed_29149 1 0 decap_w0
xfeed_29148 1 0 decap_w0
xfeed_29147 1 0 decap_w0
xfeed_29146 1 0 decap_w0
xfeed_29145 1 0 decap_w0
xfeed_29144 1 0 decap_w0
xfeed_29143 1 0 decap_w0
xfeed_29142 1 0 decap_w0
xfeed_29141 1 0 decap_w0
xfeed_29140 1 0 decap_w0
xfeed_28619 1 0 decap_w0
xfeed_28618 1 0 decap_w0
xfeed_28617 1 0 decap_w0
xfeed_28616 1 0 decap_w0
xfeed_28615 1 0 decap_w0
xfeed_28614 1 0 decap_w0
xfeed_28613 1 0 decap_w0
xfeed_28612 1 0 decap_w0
xfeed_28611 1 0 decap_w0
xfeed_28610 1 0 decap_w0
xfeed_24309 1 0 decap_w0
xfeed_24308 1 0 decap_w0
xfeed_24307 1 0 decap_w0
xfeed_24306 1 0 decap_w0
xfeed_24305 1 0 decap_w0
xfeed_24304 1 0 decap_w0
xfeed_24303 1 0 decap_w0
xfeed_24302 1 0 decap_w0
xfeed_24301 1 0 decap_w0
xfeed_24300 1 0 decap_w0
xfeed_23699 1 0 decap_w0
xfeed_23698 1 0 decap_w0
xfeed_23697 1 0 decap_w0
xfeed_23696 1 0 decap_w0
xfeed_23695 1 0 decap_w0
xfeed_23694 1 0 decap_w0
xfeed_23693 1 0 decap_w0
xfeed_23692 1 0 decap_w0
xfeed_23691 1 0 decap_w0
xfeed_23690 1 0 decap_w0
xfeed_18309 1 0 decap_w0
xfeed_18308 1 0 decap_w0
xfeed_18307 1 0 decap_w0
xfeed_18306 1 0 decap_w0
xfeed_18305 1 0 decap_w0
xfeed_18304 1 0 decap_w0
xfeed_18303 1 0 decap_w0
xfeed_18302 1 0 decap_w0
xfeed_18301 1 0 decap_w0
xfeed_18300 1 0 decap_w0
xfeed_6649 1 0 decap_w0
xfeed_6648 1 0 decap_w0
xfeed_6647 1 0 decap_w0
xfeed_319 1 0 decap_w0
xfeed_318 1 0 decap_w0
xfeed_317 1 0 decap_w0
xfeed_316 1 0 decap_w0
xfeed_315 1 0 decap_w0
xfeed_314 1 0 decap_w0
xfeed_313 1 0 decap_w0
xfeed_312 1 0 decap_w0
xfeed_311 1 0 decap_w0
xfeed_310 1 0 decap_w0
xspare_feed_261 1 0 decap_w0
xspare_feed_262 1 0 tie
xspare_feed_263 1 0 tie
xspare_feed_264 1 0 decap_w0
xspare_feed_265 1 0 tie
xspare_feed_266 1 0 tie
xspare_feed_267 1 0 decap_w0
xspare_feed_268 1 0 tie
xspare_feed_269 1 0 tie
xfeed_1808 1 0 decap_w0
xfeed_1809 1 0 decap_w0
xfeed_17699 1 0 decap_w0
xfeed_17698 1 0 decap_w0
xfeed_17697 1 0 decap_w0
xfeed_17696 1 0 decap_w0
xfeed_17695 1 0 decap_w0
xfeed_17694 1 0 decap_w0
xfeed_17693 1 0 decap_w0
xfeed_17692 1 0 decap_w0
xfeed_17691 1 0 decap_w0
xfeed_17690 1 0 decap_w0
xfeed_13389 1 0 decap_w0
xfeed_13388 1 0 decap_w0
xfeed_13387 1 0 decap_w0
xfeed_13386 1 0 decap_w0
xfeed_13385 1 0 decap_w0
xfeed_13384 1 0 decap_w0
xfeed_13383 1 0 decap_w0
xfeed_13382 1 0 decap_w0
xfeed_13381 1 0 decap_w0
xfeed_13380 1 0 decap_w0
xfeed_12859 1 0 decap_w0
xfeed_12858 1 0 decap_w0
xfeed_12857 1 0 decap_w0
xfeed_12856 1 0 decap_w0
xfeed_12855 1 0 decap_w0
xfeed_12854 1 0 decap_w0
xfeed_12853 1 0 decap_w0
xfeed_12852 1 0 decap_w0
xfeed_12851 1 0 decap_w0
xfeed_12850 1 0 decap_w0
xfeed_7189 1 0 decap_w0
xfeed_7188 1 0 decap_w0
xfeed_7187 1 0 decap_w0
xfeed_7186 1 0 decap_w0
xfeed_7185 1 0 decap_w0
xfeed_7184 1 0 decap_w0
xfeed_7183 1 0 decap_w0
xfeed_7182 1 0 decap_w0
xfeed_7181 1 0 decap_w0
xfeed_7180 1 0 decap_w0
xfeed_6653 1 0 decap_w0
xfeed_6652 1 0 decap_w0
xfeed_6651 1 0 decap_w0
xfeed_6650 1 0 decap_w0
xfeed_2349 1 0 decap_w0
xfeed_2348 1 0 decap_w0
xfeed_2347 1 0 decap_w0
xfeed_2346 1 0 decap_w0
xfeed_2345 1 0 decap_w0
xfeed_2344 1 0 decap_w0
xfeed_2343 1 0 decap_w0
xfeed_2342 1 0 decap_w0
xfeed_2341 1 0 decap_w0
xfeed_2340 1 0 decap_w0
xfeed_1810 1 0 decap_w0
xfeed_1811 1 0 decap_w0
xfeed_1812 1 0 decap_w0
xfeed_1813 1 0 decap_w0
xfeed_1814 1 0 decap_w0
xfeed_30319 1 0 decap_w0
xfeed_30318 1 0 decap_w0
xfeed_30317 1 0 decap_w0
xfeed_30316 1 0 decap_w0
xfeed_30315 1 0 decap_w0
xfeed_30314 1 0 decap_w0
xfeed_30313 1 0 decap_w0
xfeed_30312 1 0 decap_w0
xfeed_30311 1 0 decap_w0
xfeed_30310 1 0 decap_w0
xfeed_29159 1 0 decap_w0
xfeed_29158 1 0 decap_w0
xfeed_29157 1 0 decap_w0
xfeed_29156 1 0 decap_w0
xfeed_29155 1 0 decap_w0
xfeed_29154 1 0 decap_w0
xfeed_29153 1 0 decap_w0
xfeed_29152 1 0 decap_w0
xfeed_29151 1 0 decap_w0
xfeed_29150 1 0 decap_w0
xfeed_28629 1 0 decap_w0
xfeed_28628 1 0 decap_w0
xfeed_28627 1 0 decap_w0
xfeed_28626 1 0 decap_w0
xfeed_28625 1 0 decap_w0
xfeed_28624 1 0 decap_w0
xfeed_28623 1 0 decap_w0
xfeed_28622 1 0 decap_w0
xfeed_28621 1 0 decap_w0
xfeed_28620 1 0 decap_w0
xfeed_24319 1 0 decap_w0
xfeed_24318 1 0 decap_w0
xfeed_24317 1 0 decap_w0
xfeed_24316 1 0 decap_w0
xfeed_24315 1 0 decap_w0
xfeed_24314 1 0 decap_w0
xfeed_24313 1 0 decap_w0
xfeed_24312 1 0 decap_w0
xfeed_24311 1 0 decap_w0
xfeed_24310 1 0 decap_w0
xfeed_20009 1 0 decap_w0
xfeed_20008 1 0 decap_w0
xfeed_20007 1 0 decap_w0
xfeed_20006 1 0 decap_w0
xfeed_20005 1 0 decap_w0
xfeed_20004 1 0 decap_w0
xfeed_20003 1 0 decap_w0
xfeed_20002 1 0 decap_w0
xfeed_20001 1 0 decap_w0
xfeed_20000 1 0 decap_w0
xfeed_18319 1 0 decap_w0
xfeed_18318 1 0 decap_w0
xfeed_18317 1 0 decap_w0
xfeed_18316 1 0 decap_w0
xfeed_18315 1 0 decap_w0
xfeed_18314 1 0 decap_w0
xfeed_18313 1 0 decap_w0
xfeed_18312 1 0 decap_w0
xfeed_18311 1 0 decap_w0
xfeed_18310 1 0 decap_w0
xfeed_14009 1 0 decap_w0
xfeed_14008 1 0 decap_w0
xfeed_14007 1 0 decap_w0
xfeed_14006 1 0 decap_w0
xfeed_14005 1 0 decap_w0
xfeed_14004 1 0 decap_w0
xfeed_14003 1 0 decap_w0
xfeed_14002 1 0 decap_w0
xfeed_14001 1 0 decap_w0
xfeed_14000 1 0 decap_w0
xfeed_6659 1 0 decap_w0
xfeed_6658 1 0 decap_w0
xfeed_6657 1 0 decap_w0
xfeed_6656 1 0 decap_w0
xfeed_6655 1 0 decap_w0
xfeed_6654 1 0 decap_w0
xfeed_329 1 0 decap_w0
xfeed_328 1 0 decap_w0
xfeed_327 1 0 decap_w0
xfeed_326 1 0 decap_w0
xfeed_325 1 0 decap_w0
xfeed_324 1 0 decap_w0
xfeed_323 1 0 decap_w0
xfeed_322 1 0 decap_w0
xfeed_321 1 0 decap_w0
xfeed_320 1 0 decap_w0
xspare_feed_270 1 0 decap_w0
xspare_feed_271 1 0 tie
xspare_feed_272 1 0 tie
xspare_feed_273 1 0 decap_w0
xspare_feed_274 1 0 tie
xspare_feed_275 1 0 tie
xspare_feed_276 1 0 decap_w0
xspare_feed_277 1 0 tie
xspare_feed_278 1 0 tie
xspare_feed_279 1 0 decap_w0
xfeed_1815 1 0 decap_w0
xfeed_1816 1 0 decap_w0
xfeed_1817 1 0 decap_w0
xfeed_1818 1 0 decap_w0
xfeed_1819 1 0 decap_w0
xfeed_13399 1 0 decap_w0
xfeed_13398 1 0 decap_w0
xfeed_13397 1 0 decap_w0
xfeed_13396 1 0 decap_w0
xfeed_13395 1 0 decap_w0
xfeed_13394 1 0 decap_w0
xfeed_13393 1 0 decap_w0
xfeed_13392 1 0 decap_w0
xfeed_13391 1 0 decap_w0
xfeed_13390 1 0 decap_w0
xfeed_12869 1 0 decap_w0
xfeed_12868 1 0 decap_w0
xfeed_12867 1 0 decap_w0
xfeed_12866 1 0 decap_w0
xfeed_12865 1 0 decap_w0
xfeed_12864 1 0 decap_w0
xfeed_12863 1 0 decap_w0
xfeed_12862 1 0 decap_w0
xfeed_12861 1 0 decap_w0
xfeed_12860 1 0 decap_w0
xfeed_7199 1 0 decap_w0
xfeed_7198 1 0 decap_w0
xfeed_7197 1 0 decap_w0
xfeed_7196 1 0 decap_w0
xfeed_7195 1 0 decap_w0
xfeed_7194 1 0 decap_w0
xfeed_7193 1 0 decap_w0
xfeed_7192 1 0 decap_w0
xfeed_7191 1 0 decap_w0
xfeed_7190 1 0 decap_w0
xfeed_6660 1 0 decap_w0
xfeed_2359 1 0 decap_w0
xfeed_2358 1 0 decap_w0
xfeed_2357 1 0 decap_w0
xfeed_2356 1 0 decap_w0
xfeed_2355 1 0 decap_w0
xfeed_2354 1 0 decap_w0
xfeed_2353 1 0 decap_w0
xfeed_2352 1 0 decap_w0
xfeed_2351 1 0 decap_w0
xfeed_2350 1 0 decap_w0
xfeed_1820 1 0 decap_w0
xfeed_1821 1 0 decap_w0
xfeed_30329 1 0 decap_w0
xfeed_30328 1 0 decap_w0
xfeed_30327 1 0 decap_w0
xfeed_30326 1 0 decap_w0
xfeed_30325 1 0 decap_w0
xfeed_30324 1 0 decap_w0
xfeed_30323 1 0 decap_w0
xfeed_30322 1 0 decap_w0
xfeed_30321 1 0 decap_w0
xfeed_30320 1 0 decap_w0
xfeed_29169 1 0 decap_w0
xfeed_29168 1 0 decap_w0
xfeed_29167 1 0 decap_w0
xfeed_29166 1 0 decap_w0
xfeed_29165 1 0 decap_w0
xfeed_29164 1 0 decap_w0
xfeed_29163 1 0 decap_w0
xfeed_29162 1 0 decap_w0
xfeed_29161 1 0 decap_w0
xfeed_29160 1 0 decap_w0
xfeed_28639 1 0 decap_w0
xfeed_28638 1 0 decap_w0
xfeed_28637 1 0 decap_w0
xfeed_28636 1 0 decap_w0
xfeed_28635 1 0 decap_w0
xfeed_28634 1 0 decap_w0
xfeed_28633 1 0 decap_w0
xfeed_28632 1 0 decap_w0
xfeed_28631 1 0 decap_w0
xfeed_28630 1 0 decap_w0
xfeed_24329 1 0 decap_w0
xfeed_24328 1 0 decap_w0
xfeed_24327 1 0 decap_w0
xfeed_24326 1 0 decap_w0
xfeed_24325 1 0 decap_w0
xfeed_24324 1 0 decap_w0
xfeed_24323 1 0 decap_w0
xfeed_24322 1 0 decap_w0
xfeed_24321 1 0 decap_w0
xfeed_24320 1 0 decap_w0
xfeed_20019 1 0 decap_w0
xfeed_20018 1 0 decap_w0
xfeed_20017 1 0 decap_w0
xfeed_20016 1 0 decap_w0
xfeed_20015 1 0 decap_w0
xfeed_20014 1 0 decap_w0
xfeed_20013 1 0 decap_w0
xfeed_20012 1 0 decap_w0
xfeed_20011 1 0 decap_w0
xfeed_20010 1 0 decap_w0
xfeed_18326 1 0 decap_w0
xfeed_18325 1 0 decap_w0
xfeed_18324 1 0 decap_w0
xfeed_18323 1 0 decap_w0
xfeed_18322 1 0 decap_w0
xfeed_18321 1 0 decap_w0
xfeed_18320 1 0 decap_w0
xfeed_14019 1 0 decap_w0
xfeed_14018 1 0 decap_w0
xfeed_14017 1 0 decap_w0
xfeed_14016 1 0 decap_w0
xfeed_14015 1 0 decap_w0
xfeed_14014 1 0 decap_w0
xfeed_14013 1 0 decap_w0
xfeed_14012 1 0 decap_w0
xfeed_14011 1 0 decap_w0
xfeed_14010 1 0 decap_w0
xfeed_6669 1 0 decap_w0
xfeed_6668 1 0 decap_w0
xfeed_6667 1 0 decap_w0
xfeed_6666 1 0 decap_w0
xfeed_6665 1 0 decap_w0
xfeed_6664 1 0 decap_w0
xfeed_6663 1 0 decap_w0
xfeed_6662 1 0 decap_w0
xfeed_6661 1 0 decap_w0
xfeed_339 1 0 decap_w0
xfeed_338 1 0 decap_w0
xfeed_337 1 0 decap_w0
xfeed_336 1 0 decap_w0
xfeed_335 1 0 decap_w0
xfeed_334 1 0 decap_w0
xfeed_333 1 0 decap_w0
xfeed_332 1 0 decap_w0
xfeed_331 1 0 decap_w0
xfeed_330 1 0 decap_w0
xspare_feed_280 1 0 tie
xspare_feed_281 1 0 tie
xspare_feed_282 1 0 decap_w0
xspare_feed_283 1 0 tie
xspare_feed_284 1 0 tie
xspare_feed_285 1 0 decap_w0
xspare_feed_286 1 0 tie
xspare_feed_287 1 0 tie
xspare_feed_288 1 0 decap_w0
xspare_feed_289 1 0 tie
xfeed_1822 1 0 decap_w0
xfeed_1823 1 0 decap_w0
xfeed_1824 1 0 decap_w0
xfeed_1825 1 0 decap_w0
xfeed_1826 1 0 decap_w0
xfeed_1827 1 0 decap_w0
xfeed_1828 1 0 decap_w0
xfeed_1829 1 0 decap_w0
xfeed_18329 1 0 decap_w0
xfeed_18328 1 0 decap_w0
xfeed_18327 1 0 decap_w0
xfeed_12879 1 0 decap_w0
xfeed_12878 1 0 decap_w0
xfeed_12877 1 0 decap_w0
xfeed_12876 1 0 decap_w0
xfeed_12875 1 0 decap_w0
xfeed_12874 1 0 decap_w0
xfeed_12873 1 0 decap_w0
xfeed_12872 1 0 decap_w0
xfeed_12871 1 0 decap_w0
xfeed_12870 1 0 decap_w0
xfeed_2367 1 0 decap_w0
xfeed_2366 1 0 decap_w0
xfeed_2365 1 0 decap_w0
xfeed_2364 1 0 decap_w0
xfeed_2363 1 0 decap_w0
xfeed_2362 1 0 decap_w0
xfeed_2361 1 0 decap_w0
xfeed_2360 1 0 decap_w0
xfeed_30339 1 0 decap_w0
xfeed_30338 1 0 decap_w0
xfeed_30337 1 0 decap_w0
xfeed_30336 1 0 decap_w0
xfeed_30335 1 0 decap_w0
xfeed_30334 1 0 decap_w0
xfeed_30333 1 0 decap_w0
xfeed_30332 1 0 decap_w0
xfeed_30331 1 0 decap_w0
xfeed_30330 1 0 decap_w0
xfeed_29179 1 0 decap_w0
xfeed_29178 1 0 decap_w0
xfeed_29177 1 0 decap_w0
xfeed_29176 1 0 decap_w0
xfeed_29175 1 0 decap_w0
xfeed_29174 1 0 decap_w0
xfeed_29173 1 0 decap_w0
xfeed_29172 1 0 decap_w0
xfeed_29171 1 0 decap_w0
xfeed_29170 1 0 decap_w0
xfeed_28649 1 0 decap_w0
xfeed_28648 1 0 decap_w0
xfeed_28647 1 0 decap_w0
xfeed_28646 1 0 decap_w0
xfeed_28645 1 0 decap_w0
xfeed_28644 1 0 decap_w0
xfeed_28643 1 0 decap_w0
xfeed_28642 1 0 decap_w0
xfeed_28641 1 0 decap_w0
xfeed_28640 1 0 decap_w0
xfeed_24339 1 0 decap_w0
xfeed_24338 1 0 decap_w0
xfeed_24337 1 0 decap_w0
xfeed_24336 1 0 decap_w0
xfeed_24335 1 0 decap_w0
xfeed_24334 1 0 decap_w0
xfeed_24333 1 0 decap_w0
xfeed_24332 1 0 decap_w0
xfeed_24331 1 0 decap_w0
xfeed_24330 1 0 decap_w0
xfeed_23809 1 0 decap_w0
xfeed_23808 1 0 decap_w0
xfeed_23807 1 0 decap_w0
xfeed_23806 1 0 decap_w0
xfeed_23805 1 0 decap_w0
xfeed_23804 1 0 decap_w0
xfeed_23803 1 0 decap_w0
xfeed_23802 1 0 decap_w0
xfeed_23801 1 0 decap_w0
xfeed_23800 1 0 decap_w0
xfeed_20029 1 0 decap_w0
xfeed_20028 1 0 decap_w0
xfeed_20027 1 0 decap_w0
xfeed_20026 1 0 decap_w0
xfeed_20025 1 0 decap_w0
xfeed_20024 1 0 decap_w0
xfeed_20023 1 0 decap_w0
xfeed_20022 1 0 decap_w0
xfeed_20021 1 0 decap_w0
xfeed_20020 1 0 decap_w0
xfeed_18333 1 0 decap_w0
xfeed_18332 1 0 decap_w0
xfeed_18331 1 0 decap_w0
xfeed_18330 1 0 decap_w0
xfeed_14029 1 0 decap_w0
xfeed_14028 1 0 decap_w0
xfeed_14027 1 0 decap_w0
xfeed_14026 1 0 decap_w0
xfeed_14025 1 0 decap_w0
xfeed_14024 1 0 decap_w0
xfeed_14023 1 0 decap_w0
xfeed_14022 1 0 decap_w0
xfeed_14021 1 0 decap_w0
xfeed_14020 1 0 decap_w0
xfeed_6679 1 0 decap_w0
xfeed_6678 1 0 decap_w0
xfeed_6677 1 0 decap_w0
xfeed_6676 1 0 decap_w0
xfeed_6675 1 0 decap_w0
xfeed_6674 1 0 decap_w0
xfeed_6673 1 0 decap_w0
xfeed_6672 1 0 decap_w0
xfeed_6671 1 0 decap_w0
xfeed_6670 1 0 decap_w0
xfeed_2369 1 0 decap_w0
xfeed_2368 1 0 decap_w0
xfeed_349 1 0 decap_w0
xfeed_348 1 0 decap_w0
xfeed_347 1 0 decap_w0
xfeed_346 1 0 decap_w0
xfeed_345 1 0 decap_w0
xfeed_344 1 0 decap_w0
xfeed_343 1 0 decap_w0
xfeed_342 1 0 decap_w0
xfeed_341 1 0 decap_w0
xfeed_340 1 0 decap_w0
xspare_feed_290 1 0 tie
xspare_feed_291 1 0 decap_w0
xspare_feed_292 1 0 tie
xspare_feed_293 1 0 tie
xspare_feed_294 1 0 decap_w0
xspare_feed_295 1 0 tie
xspare_feed_296 1 0 tie
xspare_feed_297 1 0 decap_w0
xspare_feed_298 1 0 tie
xspare_feed_299 1 0 tie
xfeed_1830 1 0 decap_w0
xfeed_1831 1 0 decap_w0
xfeed_1832 1 0 decap_w0
xfeed_1833 1 0 decap_w0
xfeed_1834 1 0 decap_w0
xfeed_1835 1 0 decap_w0
xfeed_1836 1 0 decap_w0
xfeed_1837 1 0 decap_w0
xfeed_1838 1 0 decap_w0
xfeed_1839 1 0 decap_w0
xfeed_18339 1 0 decap_w0
xfeed_18338 1 0 decap_w0
xfeed_18337 1 0 decap_w0
xfeed_18336 1 0 decap_w0
xfeed_18335 1 0 decap_w0
xfeed_18334 1 0 decap_w0
xfeed_17809 1 0 decap_w0
xfeed_17808 1 0 decap_w0
xfeed_17807 1 0 decap_w0
xfeed_17806 1 0 decap_w0
xfeed_17805 1 0 decap_w0
xfeed_17804 1 0 decap_w0
xfeed_17803 1 0 decap_w0
xfeed_17802 1 0 decap_w0
xfeed_17801 1 0 decap_w0
xfeed_17800 1 0 decap_w0
xfeed_12889 1 0 decap_w0
xfeed_12888 1 0 decap_w0
xfeed_12887 1 0 decap_w0
xfeed_12886 1 0 decap_w0
xfeed_12885 1 0 decap_w0
xfeed_12884 1 0 decap_w0
xfeed_12883 1 0 decap_w0
xfeed_12882 1 0 decap_w0
xfeed_12881 1 0 decap_w0
xfeed_12880 1 0 decap_w0
xfeed_2374 1 0 decap_w0
xfeed_2373 1 0 decap_w0
xfeed_2372 1 0 decap_w0
xfeed_2371 1 0 decap_w0
xfeed_2370 1 0 decap_w0
xfeed_30349 1 0 decap_w0
xfeed_30348 1 0 decap_w0
xfeed_30347 1 0 decap_w0
xfeed_30346 1 0 decap_w0
xfeed_30345 1 0 decap_w0
xfeed_30344 1 0 decap_w0
xfeed_30343 1 0 decap_w0
xfeed_30342 1 0 decap_w0
xfeed_30341 1 0 decap_w0
xfeed_30340 1 0 decap_w0
xfeed_29189 1 0 decap_w0
xfeed_29188 1 0 decap_w0
xfeed_29187 1 0 decap_w0
xfeed_29186 1 0 decap_w0
xfeed_29185 1 0 decap_w0
xfeed_29184 1 0 decap_w0
xfeed_29183 1 0 decap_w0
xfeed_29182 1 0 decap_w0
xfeed_29181 1 0 decap_w0
xfeed_29180 1 0 decap_w0
xfeed_28659 1 0 decap_w0
xfeed_28658 1 0 decap_w0
xfeed_28657 1 0 decap_w0
xfeed_28656 1 0 decap_w0
xfeed_28655 1 0 decap_w0
xfeed_28654 1 0 decap_w0
xfeed_28653 1 0 decap_w0
xfeed_28652 1 0 decap_w0
xfeed_28651 1 0 decap_w0
xfeed_28650 1 0 decap_w0
xfeed_24349 1 0 decap_w0
xfeed_24348 1 0 decap_w0
xfeed_24347 1 0 decap_w0
xfeed_24346 1 0 decap_w0
xfeed_24345 1 0 decap_w0
xfeed_24344 1 0 decap_w0
xfeed_24343 1 0 decap_w0
xfeed_24342 1 0 decap_w0
xfeed_24341 1 0 decap_w0
xfeed_24340 1 0 decap_w0
xfeed_23819 1 0 decap_w0
xfeed_23818 1 0 decap_w0
xfeed_23817 1 0 decap_w0
xfeed_23816 1 0 decap_w0
xfeed_23815 1 0 decap_w0
xfeed_23814 1 0 decap_w0
xfeed_23813 1 0 decap_w0
xfeed_23812 1 0 decap_w0
xfeed_23811 1 0 decap_w0
xfeed_23810 1 0 decap_w0
xfeed_20039 1 0 decap_w0
xfeed_20038 1 0 decap_w0
xfeed_20037 1 0 decap_w0
xfeed_20036 1 0 decap_w0
xfeed_20035 1 0 decap_w0
xfeed_20034 1 0 decap_w0
xfeed_20033 1 0 decap_w0
xfeed_20032 1 0 decap_w0
xfeed_20031 1 0 decap_w0
xfeed_20030 1 0 decap_w0
xfeed_18340 1 0 decap_w0
xfeed_14039 1 0 decap_w0
xfeed_14038 1 0 decap_w0
xfeed_14037 1 0 decap_w0
xfeed_14036 1 0 decap_w0
xfeed_14035 1 0 decap_w0
xfeed_14034 1 0 decap_w0
xfeed_14033 1 0 decap_w0
xfeed_14032 1 0 decap_w0
xfeed_14031 1 0 decap_w0
xfeed_14030 1 0 decap_w0
xfeed_13501 1 0 decap_w0
xfeed_13500 1 0 decap_w0
xfeed_6689 1 0 decap_w0
xfeed_6688 1 0 decap_w0
xfeed_6687 1 0 decap_w0
xfeed_6686 1 0 decap_w0
xfeed_6685 1 0 decap_w0
xfeed_6684 1 0 decap_w0
xfeed_6683 1 0 decap_w0
xfeed_6682 1 0 decap_w0
xfeed_6681 1 0 decap_w0
xfeed_6680 1 0 decap_w0
xfeed_2379 1 0 decap_w0
xfeed_2378 1 0 decap_w0
xfeed_2377 1 0 decap_w0
xfeed_2376 1 0 decap_w0
xfeed_2375 1 0 decap_w0
xfeed_359 1 0 decap_w0
xfeed_358 1 0 decap_w0
xfeed_357 1 0 decap_w0
xfeed_356 1 0 decap_w0
xfeed_355 1 0 decap_w0
xfeed_354 1 0 decap_w0
xfeed_353 1 0 decap_w0
xfeed_352 1 0 decap_w0
xfeed_351 1 0 decap_w0
xfeed_350 1 0 decap_w0
xfeed_1840 1 0 decap_w0
xfeed_1841 1 0 decap_w0
xfeed_1842 1 0 decap_w0
xfeed_1843 1 0 decap_w0
xfeed_1844 1 0 decap_w0
xfeed_1845 1 0 decap_w0
xfeed_1846 1 0 decap_w0
xfeed_1847 1 0 decap_w0
xfeed_1848 1 0 decap_w0
xfeed_1849 1 0 decap_w0
xfeed_18349 1 0 decap_w0
xfeed_18348 1 0 decap_w0
xfeed_18347 1 0 decap_w0
xfeed_18346 1 0 decap_w0
xfeed_18345 1 0 decap_w0
xfeed_18344 1 0 decap_w0
xfeed_18343 1 0 decap_w0
xfeed_18342 1 0 decap_w0
xfeed_18341 1 0 decap_w0
xfeed_17819 1 0 decap_w0
xfeed_17818 1 0 decap_w0
xfeed_17817 1 0 decap_w0
xfeed_17816 1 0 decap_w0
xfeed_17815 1 0 decap_w0
xfeed_17814 1 0 decap_w0
xfeed_17813 1 0 decap_w0
xfeed_17812 1 0 decap_w0
xfeed_17811 1 0 decap_w0
xfeed_17810 1 0 decap_w0
xfeed_13509 1 0 decap_w0
xfeed_13508 1 0 decap_w0
xfeed_13507 1 0 decap_w0
xfeed_13506 1 0 decap_w0
xfeed_13505 1 0 decap_w0
xfeed_13504 1 0 decap_w0
xfeed_13503 1 0 decap_w0
xfeed_13502 1 0 decap_w0
xfeed_12899 1 0 decap_w0
xfeed_12898 1 0 decap_w0
xfeed_12897 1 0 decap_w0
xfeed_12896 1 0 decap_w0
xfeed_12895 1 0 decap_w0
xfeed_12894 1 0 decap_w0
xfeed_12893 1 0 decap_w0
xfeed_12892 1 0 decap_w0
xfeed_12891 1 0 decap_w0
xfeed_12890 1 0 decap_w0
xfeed_7309 1 0 decap_w0
xfeed_7308 1 0 decap_w0
xfeed_7307 1 0 decap_w0
xfeed_7306 1 0 decap_w0
xfeed_7305 1 0 decap_w0
xfeed_7304 1 0 decap_w0
xfeed_7303 1 0 decap_w0
xfeed_7302 1 0 decap_w0
xfeed_7301 1 0 decap_w0
xfeed_7300 1 0 decap_w0
xfeed_2381 1 0 decap_w0
xfeed_2380 1 0 decap_w0
xfeed_30359 1 0 decap_w0
xfeed_30358 1 0 decap_w0
xfeed_30357 1 0 decap_w0
xfeed_30356 1 0 decap_w0
xfeed_30355 1 0 decap_w0
xfeed_30354 1 0 decap_w0
xfeed_30353 1 0 decap_w0
xfeed_30352 1 0 decap_w0
xfeed_30351 1 0 decap_w0
xfeed_30350 1 0 decap_w0
xfeed_29199 1 0 decap_w0
xfeed_29198 1 0 decap_w0
xfeed_29197 1 0 decap_w0
xfeed_29196 1 0 decap_w0
xfeed_29195 1 0 decap_w0
xfeed_29194 1 0 decap_w0
xfeed_29193 1 0 decap_w0
xfeed_29192 1 0 decap_w0
xfeed_29191 1 0 decap_w0
xfeed_29190 1 0 decap_w0
xfeed_28669 1 0 decap_w0
xfeed_28668 1 0 decap_w0
xfeed_28667 1 0 decap_w0
xfeed_28666 1 0 decap_w0
xfeed_28665 1 0 decap_w0
xfeed_28664 1 0 decap_w0
xfeed_28663 1 0 decap_w0
xfeed_28662 1 0 decap_w0
xfeed_28661 1 0 decap_w0
xfeed_28660 1 0 decap_w0
xfeed_24359 1 0 decap_w0
xfeed_24358 1 0 decap_w0
xfeed_24357 1 0 decap_w0
xfeed_24356 1 0 decap_w0
xfeed_24355 1 0 decap_w0
xfeed_24354 1 0 decap_w0
xfeed_24353 1 0 decap_w0
xfeed_24352 1 0 decap_w0
xfeed_24351 1 0 decap_w0
xfeed_24350 1 0 decap_w0
xfeed_23829 1 0 decap_w0
xfeed_23828 1 0 decap_w0
xfeed_23827 1 0 decap_w0
xfeed_23826 1 0 decap_w0
xfeed_23825 1 0 decap_w0
xfeed_23824 1 0 decap_w0
xfeed_23823 1 0 decap_w0
xfeed_23822 1 0 decap_w0
xfeed_23821 1 0 decap_w0
xfeed_23820 1 0 decap_w0
xfeed_20049 1 0 decap_w0
xfeed_20048 1 0 decap_w0
xfeed_20047 1 0 decap_w0
xfeed_20046 1 0 decap_w0
xfeed_20045 1 0 decap_w0
xfeed_20044 1 0 decap_w0
xfeed_20043 1 0 decap_w0
xfeed_20042 1 0 decap_w0
xfeed_20041 1 0 decap_w0
xfeed_20040 1 0 decap_w0
xfeed_14047 1 0 decap_w0
xfeed_14046 1 0 decap_w0
xfeed_14045 1 0 decap_w0
xfeed_14044 1 0 decap_w0
xfeed_14043 1 0 decap_w0
xfeed_14042 1 0 decap_w0
xfeed_14041 1 0 decap_w0
xfeed_14040 1 0 decap_w0
xfeed_6699 1 0 decap_w0
xfeed_6698 1 0 decap_w0
xfeed_6697 1 0 decap_w0
xfeed_6696 1 0 decap_w0
xfeed_6695 1 0 decap_w0
xfeed_6694 1 0 decap_w0
xfeed_6693 1 0 decap_w0
xfeed_6692 1 0 decap_w0
xfeed_6691 1 0 decap_w0
xfeed_6690 1 0 decap_w0
xfeed_2389 1 0 decap_w0
xfeed_2388 1 0 decap_w0
xfeed_2387 1 0 decap_w0
xfeed_2386 1 0 decap_w0
xfeed_2385 1 0 decap_w0
xfeed_2384 1 0 decap_w0
xfeed_2383 1 0 decap_w0
xfeed_2382 1 0 decap_w0
xfeed_369 1 0 decap_w0
xfeed_368 1 0 decap_w0
xfeed_367 1 0 decap_w0
xfeed_366 1 0 decap_w0
xfeed_365 1 0 decap_w0
xfeed_364 1 0 decap_w0
xfeed_363 1 0 decap_w0
xfeed_362 1 0 decap_w0
xfeed_361 1 0 decap_w0
xfeed_360 1 0 decap_w0
xfeed_1850 1 0 decap_w0
xfeed_1851 1 0 decap_w0
xfeed_1852 1 0 decap_w0
xfeed_1853 1 0 decap_w0
xfeed_1854 1 0 decap_w0
xfeed_1855 1 0 decap_w0
xfeed_1856 1 0 decap_w0
xfeed_1857 1 0 decap_w0
xfeed_1858 1 0 decap_w0
xfeed_1859 1 0 decap_w0
xfeed_18359 1 0 decap_w0
xfeed_18358 1 0 decap_w0
xfeed_18357 1 0 decap_w0
xfeed_18356 1 0 decap_w0
xfeed_18355 1 0 decap_w0
xfeed_18354 1 0 decap_w0
xfeed_18353 1 0 decap_w0
xfeed_18352 1 0 decap_w0
xfeed_18351 1 0 decap_w0
xfeed_18350 1 0 tie
xfeed_17829 1 0 decap_w0
xfeed_17828 1 0 decap_w0
xfeed_17827 1 0 decap_w0
xfeed_17826 1 0 decap_w0
xfeed_17825 1 0 decap_w0
xfeed_17824 1 0 decap_w0
xfeed_17823 1 0 decap_w0
xfeed_17822 1 0 decap_w0
xfeed_17821 1 0 decap_w0
xfeed_17820 1 0 decap_w0
xfeed_14049 1 0 decap_w0
xfeed_14048 1 0 decap_w0
xfeed_13519 1 0 decap_w0
xfeed_13518 1 0 decap_w0
xfeed_13517 1 0 decap_w0
xfeed_13516 1 0 decap_w0
xfeed_13515 1 0 decap_w0
xfeed_13514 1 0 decap_w0
xfeed_13513 1 0 decap_w0
xfeed_13512 1 0 decap_w0
xfeed_13511 1 0 decap_w0
xfeed_13510 1 0 decap_w0
xfeed_7319 1 0 decap_w0
xfeed_7318 1 0 decap_w0
xfeed_7317 1 0 decap_w0
xfeed_7316 1 0 decap_w0
xfeed_7315 1 0 decap_w0
xfeed_7314 1 0 decap_w0
xfeed_7313 1 0 decap_w0
xfeed_7312 1 0 decap_w0
xfeed_7311 1 0 decap_w0
xfeed_7310 1 0 decap_w0
xfeed_3009 1 0 decap_w0
xfeed_3008 1 0 decap_w0
xfeed_3007 1 0 decap_w0
xfeed_3006 1 0 decap_w0
xfeed_3005 1 0 decap_w0
xfeed_3004 1 0 decap_w0
xfeed_3003 1 0 decap_w0
xfeed_3002 1 0 decap_w0
xfeed_3001 1 0 decap_w0
xfeed_3000 1 0 decap_w0
xfeed_30369 1 0 decap_w0
xfeed_30368 1 0 decap_w0
xfeed_30367 1 0 decap_w0
xfeed_30366 1 0 decap_w0
xfeed_30365 1 0 decap_w0
xfeed_30364 1 0 decap_w0
xfeed_30363 1 0 decap_w0
xfeed_30362 1 0 decap_w0
xfeed_30361 1 0 decap_w0
xfeed_30360 1 0 decap_w0
xfeed_28679 1 0 decap_w0
xfeed_28678 1 0 decap_w0
xfeed_28677 1 0 decap_w0
xfeed_28676 1 0 decap_w0
xfeed_28675 1 0 decap_w0
xfeed_28674 1 0 decap_w0
xfeed_28673 1 0 decap_w0
xfeed_28672 1 0 decap_w0
xfeed_28671 1 0 decap_w0
xfeed_28670 1 0 decap_w0
xfeed_24369 1 0 decap_w0
xfeed_24368 1 0 decap_w0
xfeed_24367 1 0 decap_w0
xfeed_24366 1 0 decap_w0
xfeed_24365 1 0 decap_w0
xfeed_24364 1 0 decap_w0
xfeed_24363 1 0 decap_w0
xfeed_24362 1 0 decap_w0
xfeed_24361 1 0 decap_w0
xfeed_24360 1 0 decap_w0
xfeed_23839 1 0 decap_w0
xfeed_23838 1 0 decap_w0
xfeed_23837 1 0 decap_w0
xfeed_23836 1 0 decap_w0
xfeed_23835 1 0 decap_w0
xfeed_23834 1 0 decap_w0
xfeed_23833 1 0 decap_w0
xfeed_23832 1 0 decap_w0
xfeed_23831 1 0 decap_w0
xfeed_23830 1 0 decap_w0
xfeed_20059 1 0 decap_w0
xfeed_20058 1 0 decap_w0
xfeed_20057 1 0 decap_w0
xfeed_20056 1 0 decap_w0
xfeed_20055 1 0 decap_w0
xfeed_20054 1 0 decap_w0
xfeed_20053 1 0 decap_w0
xfeed_20052 1 0 decap_w0
xfeed_20051 1 0 tie
xfeed_20050 1 0 decap_w0
xfeed_14054 1 0 decap_w0
xfeed_14053 1 0 decap_w0
xfeed_14052 1 0 decap_w0
xfeed_14051 1 0 decap_w0
xfeed_14050 1 0 decap_w0
xfeed_2399 1 0 decap_w0
xfeed_2398 1 0 decap_w0
xfeed_2397 1 0 decap_w0
xfeed_2396 1 0 decap_w0
xfeed_2395 1 0 decap_w0
xfeed_2394 1 0 decap_w0
xfeed_2393 1 0 decap_w0
xfeed_2392 1 0 decap_w0
xfeed_2391 1 0 decap_w0
xfeed_2390 1 0 decap_w0
xfeed_379 1 0 decap_w0
xfeed_378 1 0 decap_w0
xfeed_377 1 0 decap_w0
xfeed_376 1 0 decap_w0
xfeed_375 1 0 decap_w0
xfeed_374 1 0 decap_w0
xfeed_373 1 0 decap_w0
xfeed_372 1 0 decap_w0
xfeed_371 1 0 decap_w0
xfeed_370 1 0 decap_w0
xfeed_1860 1 0 decap_w0
xfeed_1861 1 0 decap_w0
xfeed_1862 1 0 decap_w0
xfeed_1863 1 0 decap_w0
xfeed_1864 1 0 decap_w0
xfeed_1865 1 0 decap_w0
xfeed_1866 1 0 decap_w0
xfeed_1867 1 0 decap_w0
xfeed_1868 1 0 decap_w0
xfeed_1869 1 0 decap_w0
xfeed_18369 1 0 decap_w0
xfeed_18368 1 0 decap_w0
xfeed_18367 1 0 decap_w0
xfeed_18366 1 0 decap_w0
xfeed_18365 1 0 decap_w0
xfeed_18364 1 0 decap_w0
xfeed_18363 1 0 decap_w0
xfeed_18362 1 0 decap_w0
xfeed_18361 1 0 decap_w0
xfeed_18360 1 0 decap_w0
xfeed_17839 1 0 decap_w0
xfeed_17838 1 0 decap_w0
xfeed_17837 1 0 decap_w0
xfeed_17836 1 0 decap_w0
xfeed_17835 1 0 decap_w0
xfeed_17834 1 0 decap_w0
xfeed_17833 1 0 decap_w0
xfeed_17832 1 0 decap_w0
xfeed_17831 1 0 decap_w0
xfeed_17830 1 0 decap_w0
xfeed_14059 1 0 decap_w0
xfeed_14058 1 0 decap_w0
xfeed_14057 1 0 decap_w0
xfeed_14056 1 0 decap_w0
xfeed_14055 1 0 decap_w0
xfeed_13529 1 0 decap_w0
xfeed_13528 1 0 decap_w0
xfeed_13527 1 0 decap_w0
xfeed_13526 1 0 decap_w0
xfeed_13525 1 0 decap_w0
xfeed_13524 1 0 decap_w0
xfeed_13523 1 0 decap_w0
xfeed_13522 1 0 decap_w0
xfeed_13521 1 0 decap_w0
xfeed_13520 1 0 decap_w0
xfeed_7329 1 0 decap_w0
xfeed_7328 1 0 decap_w0
xfeed_7327 1 0 decap_w0
xfeed_7326 1 0 decap_w0
xfeed_7325 1 0 decap_w0
xfeed_7324 1 0 decap_w0
xfeed_7323 1 0 decap_w0
xfeed_7322 1 0 decap_w0
xfeed_7321 1 0 decap_w0
xfeed_7320 1 0 decap_w0
xfeed_3019 1 0 decap_w0
xfeed_3018 1 0 decap_w0
xfeed_3017 1 0 decap_w0
xfeed_3016 1 0 decap_w0
xfeed_3015 1 0 decap_w0
xfeed_3014 1 0 decap_w0
xfeed_3013 1 0 decap_w0
xfeed_3012 1 0 decap_w0
xfeed_3011 1 0 decap_w0
xfeed_3010 1 0 decap_w0
xfeed_30379 1 0 decap_w0
xfeed_30378 1 0 decap_w0
xfeed_30377 1 0 decap_w0
xfeed_30376 1 0 decap_w0
xfeed_30375 1 0 decap_w0
xfeed_30374 1 0 decap_w0
xfeed_30373 1 0 decap_w0
xfeed_30372 1 0 decap_w0
xfeed_30371 1 0 decap_w0
xfeed_30370 1 0 decap_w0
xfeed_28688 1 0 decap_w0
xfeed_28687 1 0 decap_w0
xfeed_28686 1 0 decap_w0
xfeed_28685 1 0 decap_w0
xfeed_28684 1 0 decap_w0
xfeed_28683 1 0 decap_w0
xfeed_28682 1 0 decap_w0
xfeed_28681 1 0 decap_w0
xfeed_28680 1 0 decap_w0
xfeed_24379 1 0 decap_w0
xfeed_24378 1 0 decap_w0
xfeed_24377 1 0 decap_w0
xfeed_24376 1 0 decap_w0
xfeed_24375 1 0 decap_w0
xfeed_24374 1 0 decap_w0
xfeed_24373 1 0 decap_w0
xfeed_24372 1 0 decap_w0
xfeed_24371 1 0 decap_w0
xfeed_24370 1 0 decap_w0
xfeed_23849 1 0 decap_w0
xfeed_23848 1 0 decap_w0
xfeed_23847 1 0 decap_w0
xfeed_23846 1 0 decap_w0
xfeed_23845 1 0 decap_w0
xfeed_23844 1 0 decap_w0
xfeed_23843 1 0 decap_w0
xfeed_23842 1 0 decap_w0
xfeed_23841 1 0 decap_w0
xfeed_23840 1 0 decap_w0
xfeed_20069 1 0 tie
xfeed_20068 1 0 decap_w0
xfeed_20067 1 0 decap_w0
xfeed_20066 1 0 decap_w0
xfeed_20065 1 0 decap_w0
xfeed_20064 1 0 decap_w0
xfeed_20063 1 0 decap_w0
xfeed_20062 1 0 decap_w0
xfeed_20061 1 0 decap_w0
xfeed_20060 1 0 decap_w0
xfeed_14061 1 0 decap_w0
xfeed_14060 1 0 decap_w0
xfeed_389 1 0 decap_w0
xfeed_388 1 0 decap_w0
xfeed_387 1 0 decap_w0
xfeed_386 1 0 decap_w0
xfeed_385 1 0 decap_w0
xfeed_384 1 0 decap_w0
xfeed_383 1 0 decap_w0
xfeed_382 1 0 decap_w0
xfeed_381 1 0 decap_w0
xfeed_380 1 0 decap_w0
xfeed_1870 1 0 decap_w0
xfeed_1871 1 0 decap_w0
xfeed_1872 1 0 decap_w0
xfeed_1873 1 0 decap_w0
xfeed_1874 1 0 decap_w0
xfeed_1875 1 0 decap_w0
xfeed_1876 1 0 decap_w0
xfeed_1877 1 0 decap_w0
xfeed_1878 1 0 decap_w0
xfeed_1879 1 0 decap_w0
xfeed_28689 1 0 decap_w0
xfeed_18379 1 0 decap_w0
xfeed_18378 1 0 decap_w0
xfeed_18377 1 0 decap_w0
xfeed_18376 1 0 decap_w0
xfeed_18375 1 0 decap_w0
xfeed_18374 1 0 decap_w0
xfeed_18373 1 0 decap_w0
xfeed_18372 1 0 decap_w0
xfeed_18371 1 0 decap_w0
xfeed_18370 1 0 decap_w0
xfeed_17849 1 0 decap_w0
xfeed_17848 1 0 decap_w0
xfeed_17847 1 0 decap_w0
xfeed_17846 1 0 tie
xfeed_17845 1 0 decap_w0
xfeed_17844 1 0 decap_w0
xfeed_17843 1 0 decap_w0
xfeed_17842 1 0 decap_w0
xfeed_17841 1 0 decap_w0
xfeed_17840 1 0 decap_w0
xfeed_14069 1 0 decap_w0
xfeed_14068 1 0 decap_w0
xfeed_14067 1 0 decap_w0
xfeed_14066 1 0 decap_w0
xfeed_14065 1 0 decap_w0
xfeed_14064 1 0 decap_w0
xfeed_14063 1 0 decap_w0
xfeed_14062 1 0 decap_w0
xfeed_13539 1 0 decap_w0
xfeed_13538 1 0 decap_w0
xfeed_13537 1 0 decap_w0
xfeed_13536 1 0 decap_w0
xfeed_13535 1 0 decap_w0
xfeed_13534 1 0 decap_w0
xfeed_13533 1 0 decap_w0
xfeed_13532 1 0 decap_w0
xfeed_13531 1 0 decap_w0
xfeed_13530 1 0 decap_w0
xfeed_7339 1 0 decap_w0
xfeed_7338 1 0 decap_w0
xfeed_7337 1 0 decap_w0
xfeed_7336 1 0 decap_w0
xfeed_7335 1 0 decap_w0
xfeed_7334 1 0 decap_w0
xfeed_7333 1 0 decap_w0
xfeed_7332 1 0 decap_w0
xfeed_7331 1 0 decap_w0
xfeed_7330 1 0 decap_w0
xfeed_6800 1 0 decap_w0
xfeed_3029 1 0 decap_w0
xfeed_3028 1 0 decap_w0
xfeed_3027 1 0 decap_w0
xfeed_3026 1 0 decap_w0
xfeed_3025 1 0 decap_w0
xfeed_3024 1 0 decap_w0
xfeed_3023 1 0 decap_w0
xfeed_3022 1 0 decap_w0
xfeed_3021 1 0 decap_w0
xfeed_3020 1 0 decap_w0
xfeed_30389 1 0 decap_w0
xfeed_30388 1 0 decap_w0
xfeed_30387 1 0 decap_w0
xfeed_30386 1 0 decap_w0
xfeed_30385 1 0 decap_w0
xfeed_30384 1 0 decap_w0
xfeed_30383 1 0 decap_w0
xfeed_30382 1 0 decap_w0
xfeed_30381 1 0 decap_w0
xfeed_30380 1 0 decap_w0
xfeed_29309 1 0 decap_w0
xfeed_29308 1 0 decap_w0
xfeed_29307 1 0 decap_w0
xfeed_29306 1 0 decap_w0
xfeed_29305 1 0 decap_w0
xfeed_29304 1 0 decap_w0
xfeed_29303 1 0 decap_w0
xfeed_29302 1 0 decap_w0
xfeed_29301 1 0 decap_w0
xfeed_29300 1 0 decap_w0
xfeed_28695 1 0 decap_w0
xfeed_28694 1 0 decap_w0
xfeed_28693 1 0 decap_w0
xfeed_28692 1 0 decap_w0
xfeed_28691 1 0 decap_w0
xfeed_28690 1 0 decap_w0
xfeed_24389 1 0 decap_w0
xfeed_24388 1 0 decap_w0
xfeed_24387 1 0 decap_w0
xfeed_24386 1 0 decap_w0
xfeed_24385 1 0 decap_w0
xfeed_24384 1 0 decap_w0
xfeed_24383 1 0 decap_w0
xfeed_24382 1 0 decap_w0
xfeed_24381 1 0 decap_w0
xfeed_24380 1 0 decap_w0
xfeed_23856 1 0 decap_w0
xfeed_23855 1 0 decap_w0
xfeed_23854 1 0 decap_w0
xfeed_23853 1 0 decap_w0
xfeed_23852 1 0 decap_w0
xfeed_23851 1 0 decap_w0
xfeed_23850 1 0 decap_w0
xfeed_20079 1 0 decap_w0
xfeed_20078 1 0 decap_w0
xfeed_20077 1 0 decap_w0
xfeed_20076 1 0 decap_w0
xfeed_20075 1 0 decap_w0
xfeed_20074 1 0 decap_w0
xfeed_20073 1 0 decap_w0
xfeed_20072 1 0 decap_w0
xfeed_20071 1 0 decap_w0
xfeed_20070 1 0 decap_w0
xfeed_6809 1 0 decap_w0
xfeed_6808 1 0 decap_w0
xfeed_6807 1 0 decap_w0
xfeed_6806 1 0 decap_w0
xfeed_6805 1 0 decap_w0
xfeed_6804 1 0 decap_w0
xfeed_6803 1 0 decap_w0
xfeed_6802 1 0 decap_w0
xfeed_6801 1 0 decap_w0
xfeed_399 1 0 decap_w0
xfeed_398 1 0 decap_w0
xfeed_397 1 0 decap_w0
xfeed_396 1 0 decap_w0
xfeed_395 1 0 decap_w0
xfeed_394 1 0 decap_w0
xfeed_393 1 0 decap_w0
xfeed_392 1 0 decap_w0
xfeed_391 1 0 decap_w0
xfeed_390 1 0 decap_w0
xfeed_1880 1 0 decap_w0
xfeed_1881 1 0 decap_w0
xfeed_1882 1 0 decap_w0
xfeed_1883 1 0 decap_w0
xfeed_1884 1 0 decap_w0
xfeed_1885 1 0 decap_w0
xfeed_1886 1 0 decap_w0
xfeed_1887 1 0 decap_w0
xfeed_1888 1 0 decap_w0
xfeed_1889 1 0 decap_w0
xfeed_31002 1 0 decap_w0
xfeed_31001 1 0 decap_w0
xfeed_31000 1 0 decap_w0
xfeed_28699 1 0 decap_w0
xfeed_28698 1 0 decap_w0
xfeed_28697 1 0 decap_w0
xfeed_28696 1 0 decap_w0
xfeed_23859 1 0 decap_w0
xfeed_23858 1 0 decap_w0
xfeed_23857 1 0 decap_w0
xfeed_18389 1 0 decap_w0
xfeed_18388 1 0 decap_w0
xfeed_18387 1 0 decap_w0
xfeed_18386 1 0 decap_w0
xfeed_18385 1 0 decap_w0
xfeed_18384 1 0 decap_w0
xfeed_18383 1 0 decap_w0
xfeed_18382 1 0 decap_w0
xfeed_18381 1 0 decap_w0
xfeed_18380 1 0 decap_w0
xfeed_17859 1 0 decap_w0
xfeed_17858 1 0 decap_w0
xfeed_17857 1 0 decap_w0
xfeed_17856 1 0 decap_w0
xfeed_17855 1 0 decap_w0
xfeed_17854 1 0 decap_w0
xfeed_17853 1 0 decap_w0
xfeed_17852 1 0 decap_w0
xfeed_17851 1 0 decap_w0
xfeed_17850 1 0 decap_w0
xfeed_14079 1 0 decap_w0
xfeed_14078 1 0 decap_w0
xfeed_14077 1 0 decap_w0
xfeed_14076 1 0 decap_w0
xfeed_14075 1 0 decap_w0
xfeed_14074 1 0 decap_w0
xfeed_14073 1 0 decap_w0
xfeed_14072 1 0 decap_w0
xfeed_14071 1 0 decap_w0
xfeed_14070 1 0 decap_w0
xfeed_13549 1 0 decap_w0
xfeed_13548 1 0 decap_w0
xfeed_13547 1 0 decap_w0
xfeed_13546 1 0 decap_w0
xfeed_13545 1 0 decap_w0
xfeed_13544 1 0 decap_w0
xfeed_13543 1 0 decap_w0
xfeed_13542 1 0 decap_w0
xfeed_13541 1 0 decap_w0
xfeed_13540 1 0 decap_w0
xfeed_7346 1 0 decap_w0
xfeed_7345 1 0 decap_w0
xfeed_7344 1 0 decap_w0
xfeed_7343 1 0 decap_w0
xfeed_7342 1 0 decap_w0
xfeed_7341 1 0 decap_w0
xfeed_7340 1 0 decap_w0
xfeed_3039 1 0 decap_w0
xfeed_3038 1 0 decap_w0
xfeed_3037 1 0 decap_w0
xfeed_3036 1 0 decap_w0
xfeed_3035 1 0 decap_w0
xfeed_3034 1 0 decap_w0
xfeed_3033 1 0 decap_w0
xfeed_3032 1 0 decap_w0
xfeed_3031 1 0 decap_w0
xfeed_3030 1 0 decap_w0
xfeed_2507 1 0 decap_w0
xfeed_2506 1 0 decap_w0
xfeed_2505 1 0 decap_w0
xfeed_2504 1 0 decap_w0
xfeed_2503 1 0 decap_w0
xfeed_2502 1 0 decap_w0
xfeed_2501 1 0 decap_w0
xfeed_2500 1 0 decap_w0
xfeed_31009 1 0 decap_w0
xfeed_31008 1 0 decap_w0
xfeed_31007 1 0 decap_w0
xfeed_31006 1 0 decap_w0
xfeed_31005 1 0 decap_w0
xfeed_31004 1 0 decap_w0
xfeed_31003 1 0 decap_w0
xfeed_30399 1 0 decap_w0
xfeed_30398 1 0 decap_w0
xfeed_30397 1 0 decap_w0
xfeed_30396 1 0 decap_w0
xfeed_30395 1 0 decap_w0
xfeed_30394 1 0 decap_w0
xfeed_30393 1 0 decap_w0
xfeed_30392 1 0 decap_w0
xfeed_30391 1 0 decap_w0
xfeed_30390 1 0 decap_w0
xfeed_29319 1 0 decap_w0
xfeed_29318 1 0 decap_w0
xfeed_29317 1 0 decap_w0
xfeed_29316 1 0 decap_w0
xfeed_29315 1 0 decap_w0
xfeed_29314 1 0 decap_w0
xfeed_29313 1 0 decap_w0
xfeed_29312 1 0 decap_w0
xfeed_29311 1 0 decap_w0
xfeed_29310 1 0 decap_w0
xfeed_25009 1 0 decap_w0
xfeed_25008 1 0 decap_w0
xfeed_25007 1 0 decap_w0
xfeed_25006 1 0 decap_w0
xfeed_25005 1 0 decap_w0
xfeed_25004 1 0 decap_w0
xfeed_25003 1 0 decap_w0
xfeed_25002 1 0 decap_w0
xfeed_25001 1 0 decap_w0
xfeed_25000 1 0 decap_w0
xfeed_24399 1 0 decap_w0
xfeed_24398 1 0 decap_w0
xfeed_24397 1 0 decap_w0
xfeed_24396 1 0 decap_w0
xfeed_24395 1 0 decap_w0
xfeed_24394 1 0 decap_w0
xfeed_24393 1 0 decap_w0
xfeed_24392 1 0 decap_w0
xfeed_24391 1 0 decap_w0
xfeed_24390 1 0 decap_w0
xfeed_23863 1 0 decap_w0
xfeed_23862 1 0 decap_w0
xfeed_23861 1 0 decap_w0
xfeed_23860 1 0 decap_w0
xfeed_20089 1 0 decap_w0
xfeed_20088 1 0 decap_w0
xfeed_20087 1 0 decap_w0
xfeed_20086 1 0 decap_w0
xfeed_20085 1 0 decap_w0
xfeed_20084 1 0 decap_w0
xfeed_20083 1 0 decap_w0
xfeed_20082 1 0 decap_w0
xfeed_20081 1 0 decap_w0
xfeed_20080 1 0 decap_w0
xfeed_19009 1 0 decap_w0
xfeed_19008 1 0 decap_w0
xfeed_19007 1 0 decap_w0
xfeed_19006 1 0 decap_w0
xfeed_19005 1 0 decap_w0
xfeed_19004 1 0 decap_w0
xfeed_19003 1 0 decap_w0
xfeed_19002 1 0 decap_w0
xfeed_19001 1 0 decap_w0
xfeed_19000 1 0 decap_w0
xfeed_7349 1 0 decap_w0
xfeed_7348 1 0 decap_w0
xfeed_7347 1 0 decap_w0
xfeed_6819 1 0 decap_w0
xfeed_6818 1 0 decap_w0
xfeed_6817 1 0 decap_w0
xfeed_6816 1 0 decap_w0
xfeed_6815 1 0 decap_w0
xfeed_6814 1 0 decap_w0
xfeed_6813 1 0 decap_w0
xfeed_6812 1 0 decap_w0
xfeed_6811 1 0 decap_w0
xfeed_6810 1 0 decap_w0
xfeed_2509 1 0 decap_w0
xfeed_2508 1 0 decap_w0
xfeed_1890 1 0 decap_w0
xfeed_1891 1 0 decap_w0
xfeed_1892 1 0 decap_w0
xfeed_1893 1 0 decap_w0
xfeed_1894 1 0 decap_w0
xfeed_1895 1 0 decap_w0
xfeed_1896 1 0 decap_w0
xfeed_1897 1 0 decap_w0
xfeed_1898 1 0 decap_w0
xfeed_1899 1 0 decap_w0
xfeed_23869 1 0 decap_w0
xfeed_23868 1 0 decap_w0
xfeed_23867 1 0 decap_w0
xfeed_23866 1 0 decap_w0
xfeed_23865 1 0 decap_w0
xfeed_23864 1 0 decap_w0
xfeed_18399 1 0 decap_w0
xfeed_18398 1 0 decap_w0
xfeed_18397 1 0 decap_w0
xfeed_18396 1 0 decap_w0
xfeed_18395 1 0 decap_w0
xfeed_18394 1 0 decap_w0
xfeed_18393 1 0 decap_w0
xfeed_18392 1 0 decap_w0
xfeed_18391 1 0 decap_w0
xfeed_18390 1 0 decap_w0
xfeed_17869 1 0 decap_w0
xfeed_17868 1 0 decap_w0
xfeed_17867 1 0 decap_w0
xfeed_17866 1 0 decap_w0
xfeed_17865 1 0 decap_w0
xfeed_17864 1 0 decap_w0
xfeed_17863 1 0 decap_w0
xfeed_17862 1 0 decap_w0
xfeed_17861 1 0 decap_w0
xfeed_17860 1 0 decap_w0
xfeed_14089 1 0 decap_w0
xfeed_14088 1 0 decap_w0
xfeed_14087 1 0 decap_w0
xfeed_14086 1 0 decap_w0
xfeed_14085 1 0 decap_w0
xfeed_14084 1 0 decap_w0
xfeed_14083 1 0 decap_w0
xfeed_14082 1 0 decap_w0
xfeed_14081 1 0 decap_w0
xfeed_14080 1 0 decap_w0
xfeed_13559 1 0 decap_w0
xfeed_13558 1 0 decap_w0
xfeed_13557 1 0 decap_w0
xfeed_13556 1 0 decap_w0
xfeed_13555 1 0 decap_w0
xfeed_13554 1 0 decap_w0
xfeed_13553 1 0 decap_w0
xfeed_13552 1 0 decap_w0
xfeed_13551 1 0 decap_w0
xfeed_13550 1 0 decap_w0
xfeed_7353 1 0 decap_w0
xfeed_7352 1 0 decap_w0
xfeed_7351 1 0 decap_w0
xfeed_7350 1 0 decap_w0
xfeed_3049 1 0 decap_w0
xfeed_3048 1 0 decap_w0
xfeed_3047 1 0 decap_w0
xfeed_3046 1 0 decap_w0
xfeed_3045 1 0 decap_w0
xfeed_3044 1 0 decap_w0
xfeed_3043 1 0 decap_w0
xfeed_3042 1 0 decap_w0
xfeed_3041 1 0 decap_w0
xfeed_3040 1 0 decap_w0
xfeed_2514 1 0 decap_w0
xfeed_2513 1 0 decap_w0
xfeed_2512 1 0 decap_w0
xfeed_2511 1 0 decap_w0
xfeed_2510 1 0 decap_w0
xfeed_31019 1 0 decap_w0
xfeed_31018 1 0 decap_w0
xfeed_31017 1 0 decap_w0
xfeed_31016 1 0 decap_w0
xfeed_31015 1 0 decap_w0
xfeed_31014 1 0 decap_w0
xfeed_31013 1 0 decap_w0
xfeed_31012 1 0 decap_w0
xfeed_31011 1 0 decap_w0
xfeed_31010 1 0 decap_w0
xfeed_29329 1 0 decap_w0
xfeed_29328 1 0 decap_w0
xfeed_29327 1 0 decap_w0
xfeed_29326 1 0 decap_w0
xfeed_29325 1 0 decap_w0
xfeed_29324 1 0 decap_w0
xfeed_29323 1 0 decap_w0
xfeed_29322 1 0 decap_w0
xfeed_29321 1 0 decap_w0
xfeed_29320 1 0 decap_w0
xfeed_25019 1 0 decap_w0
xfeed_25018 1 0 decap_w0
xfeed_25017 1 0 decap_w0
xfeed_25016 1 0 decap_w0
xfeed_25015 1 0 decap_w0
xfeed_25014 1 0 decap_w0
xfeed_25013 1 0 decap_w0
xfeed_25012 1 0 decap_w0
xfeed_25011 1 0 decap_w0
xfeed_25010 1 0 decap_w0
xfeed_23870 1 0 decap_w0
xfeed_20099 1 0 decap_w0
xfeed_20098 1 0 decap_w0
xfeed_20097 1 0 decap_w0
xfeed_20096 1 0 decap_w0
xfeed_20095 1 0 decap_w0
xfeed_20094 1 0 decap_w0
xfeed_20093 1 0 decap_w0
xfeed_20092 1 0 decap_w0
xfeed_20091 1 0 decap_w0
xfeed_20090 1 0 decap_w0
xfeed_19019 1 0 decap_w0
xfeed_19018 1 0 decap_w0
xfeed_19017 1 0 decap_w0
xfeed_19016 1 0 decap_w0
xfeed_19015 1 0 decap_w0
xfeed_19014 1 0 decap_w0
xfeed_19013 1 0 decap_w0
xfeed_19012 1 0 decap_w0
xfeed_19011 1 0 decap_w0
xfeed_19010 1 0 decap_w0
xfeed_7359 1 0 decap_w0
xfeed_7358 1 0 decap_w0
xfeed_7357 1 0 decap_w0
xfeed_7356 1 0 decap_w0
xfeed_7355 1 0 decap_w0
xfeed_7354 1 0 decap_w0
xfeed_6829 1 0 decap_w0
xfeed_6828 1 0 decap_w0
xfeed_6827 1 0 decap_w0
xfeed_6826 1 0 decap_w0
xfeed_6825 1 0 decap_w0
xfeed_6824 1 0 decap_w0
xfeed_6823 1 0 decap_w0
xfeed_6822 1 0 decap_w0
xfeed_6821 1 0 decap_w0
xfeed_6820 1 0 decap_w0
xfeed_2519 1 0 decap_w0
xfeed_2518 1 0 decap_w0
xfeed_2517 1 0 decap_w0
xfeed_2516 1 0 decap_w0
xfeed_2515 1 0 decap_w0
xfeed_23879 1 0 decap_w0
xfeed_23878 1 0 decap_w0
xfeed_23877 1 0 decap_w0
xfeed_23876 1 0 decap_w0
xfeed_23875 1 0 decap_w0
xfeed_23874 1 0 decap_w0
xfeed_23873 1 0 decap_w0
xfeed_23872 1 0 decap_w0
xfeed_23871 1 0 decap_w0
xfeed_17879 1 0 decap_w0
xfeed_17878 1 0 decap_w0
xfeed_17877 1 0 decap_w0
xfeed_17876 1 0 decap_w0
xfeed_17875 1 0 decap_w0
xfeed_17874 1 0 decap_w0
xfeed_17873 1 0 decap_w0
xfeed_17872 1 0 decap_w0
xfeed_17871 1 0 decap_w0
xfeed_17870 1 0 decap_w0
xfeed_14099 1 0 decap_w0
xfeed_14098 1 0 decap_w0
xfeed_14097 1 0 decap_w0
xfeed_14096 1 0 decap_w0
xfeed_14095 1 0 decap_w0
xfeed_14094 1 0 decap_w0
xfeed_14093 1 0 decap_w0
xfeed_14092 1 0 decap_w0
xfeed_14091 1 0 tie
xfeed_14090 1 0 decap_w0
xfeed_13569 1 0 decap_w0
xfeed_13568 1 0 decap_w0
xfeed_13567 1 0 decap_w0
xfeed_13566 1 0 decap_w0
xfeed_13565 1 0 decap_w0
xfeed_13564 1 0 decap_w0
xfeed_13563 1 0 decap_w0
xfeed_13562 1 0 decap_w0
xfeed_13561 1 0 tie
xfeed_13560 1 0 decap_w0
xfeed_7360 1 0 decap_w0
xfeed_3059 1 0 decap_w0
xfeed_3058 1 0 decap_w0
xfeed_3057 1 0 decap_w0
xfeed_3056 1 0 decap_w0
xfeed_3055 1 0 decap_w0
xfeed_3054 1 0 decap_w0
xfeed_3053 1 0 decap_w0
xfeed_3052 1 0 decap_w0
xfeed_3051 1 0 decap_w0
xfeed_3050 1 0 decap_w0
xfeed_2521 1 0 decap_w0
xfeed_2520 1 0 decap_w0
xfeed_31029 1 0 decap_w0
xfeed_31028 1 0 decap_w0
xfeed_31027 1 0 decap_w0
xfeed_31026 1 0 decap_w0
xfeed_31025 1 0 decap_w0
xfeed_31024 1 0 decap_w0
xfeed_31023 1 0 decap_w0
xfeed_31022 1 0 decap_w0
xfeed_31021 1 0 decap_w0
xfeed_31020 1 0 decap_w0
xfeed_29339 1 0 decap_w0
xfeed_29338 1 0 decap_w0
xfeed_29337 1 0 decap_w0
xfeed_29336 1 0 decap_w0
xfeed_29335 1 0 decap_w0
xfeed_29334 1 0 decap_w0
xfeed_29333 1 0 decap_w0
xfeed_29332 1 0 decap_w0
xfeed_29331 1 0 decap_w0
xfeed_29330 1 0 decap_w0
xfeed_28809 1 0 decap_w0
xfeed_28808 1 0 decap_w0
xfeed_28807 1 0 decap_w0
xfeed_28806 1 0 decap_w0
xfeed_28805 1 0 decap_w0
xfeed_28804 1 0 decap_w0
xfeed_28803 1 0 decap_w0
xfeed_28802 1 0 decap_w0
xfeed_28801 1 0 decap_w0
xfeed_28800 1 0 decap_w0
xfeed_25029 1 0 decap_w0
xfeed_25028 1 0 decap_w0
xfeed_25027 1 0 decap_w0
xfeed_25026 1 0 decap_w0
xfeed_25025 1 0 decap_w0
xfeed_25024 1 0 decap_w0
xfeed_25023 1 0 decap_w0
xfeed_25022 1 0 decap_w0
xfeed_25021 1 0 decap_w0
xfeed_25020 1 0 decap_w0
xfeed_19026 1 0 decap_w0
xfeed_19025 1 0 decap_w0
xfeed_19024 1 0 decap_w0
xfeed_19023 1 0 decap_w0
xfeed_19022 1 0 decap_w0
xfeed_19021 1 0 decap_w0
xfeed_19020 1 0 decap_w0
xfeed_7369 1 0 decap_w0
xfeed_7368 1 0 decap_w0
xfeed_7367 1 0 decap_w0
xfeed_7366 1 0 decap_w0
xfeed_7365 1 0 decap_w0
xfeed_7364 1 0 decap_w0
xfeed_7363 1 0 decap_w0
xfeed_7362 1 0 decap_w0
xfeed_7361 1 0 decap_w0
xfeed_6839 1 0 decap_w0
xfeed_6838 1 0 decap_w0
xfeed_6837 1 0 decap_w0
xfeed_6836 1 0 decap_w0
xfeed_6835 1 0 decap_w0
xfeed_6834 1 0 decap_w0
xfeed_6833 1 0 decap_w0
xfeed_6832 1 0 decap_w0
xfeed_6831 1 0 decap_w0
xfeed_6830 1 0 decap_w0
xfeed_2529 1 0 decap_w0
xfeed_2528 1 0 decap_w0
xfeed_2527 1 0 decap_w0
xfeed_2526 1 0 decap_w0
xfeed_2525 1 0 decap_w0
xfeed_2524 1 0 decap_w0
xfeed_2523 1 0 decap_w0
xfeed_2522 1 0 decap_w0
xfeed_509 1 0 decap_w0
xfeed_508 1 0 decap_w0
xfeed_507 1 0 decap_w0
xfeed_506 1 0 decap_w0
xfeed_505 1 0 decap_w0
xfeed_504 1 0 decap_w0
xfeed_503 1 0 decap_w0
xfeed_502 1 0 decap_w0
xfeed_501 1 0 decap_w0
xfeed_500 1 0 decap_w0
xfeed_23889 1 0 decap_w0
xfeed_23888 1 0 decap_w0
xfeed_23887 1 0 decap_w0
xfeed_23886 1 0 decap_w0
xfeed_23885 1 0 decap_w0
xfeed_23884 1 0 decap_w0
xfeed_23883 1 0 decap_w0
xfeed_23882 1 0 decap_w0
xfeed_23881 1 0 decap_w0
xfeed_23880 1 0 decap_w0
xfeed_19029 1 0 decap_w0
xfeed_19028 1 0 decap_w0
xfeed_19027 1 0 decap_w0
xfeed_17889 1 0 decap_w0
xfeed_17888 1 0 decap_w0
xfeed_17887 1 0 decap_w0
xfeed_17886 1 0 decap_w0
xfeed_17885 1 0 decap_w0
xfeed_17884 1 0 decap_w0
xfeed_17883 1 0 decap_w0
xfeed_17882 1 0 decap_w0
xfeed_17881 1 0 decap_w0
xfeed_17880 1 0 decap_w0
xfeed_13579 1 0 decap_w0
xfeed_13578 1 0 decap_w0
xfeed_13577 1 0 decap_w0
xfeed_13576 1 0 decap_w0
xfeed_13575 1 0 decap_w0
xfeed_13574 1 0 decap_w0
xfeed_13573 1 0 decap_w0
xfeed_13572 1 0 decap_w0
xfeed_13571 1 0 decap_w0
xfeed_13570 1 0 decap_w0
xfeed_3067 1 0 decap_w0
xfeed_3066 1 0 decap_w0
xfeed_3065 1 0 decap_w0
xfeed_3064 1 0 decap_w0
xfeed_3063 1 0 decap_w0
xfeed_3062 1 0 decap_w0
xfeed_3061 1 0 decap_w0
xfeed_3060 1 0 decap_w0
xfeed_31039 1 0 decap_w0
xfeed_31038 1 0 decap_w0
xfeed_31037 1 0 decap_w0
xfeed_31036 1 0 decap_w0
xfeed_31035 1 0 decap_w0
xfeed_31034 1 0 decap_w0
xfeed_31033 1 0 decap_w0
xfeed_31032 1 0 decap_w0
xfeed_31031 1 0 decap_w0
xfeed_31030 1 0 decap_w0
xfeed_30509 1 0 decap_w0
xfeed_30508 1 0 decap_w0
xfeed_30507 1 0 decap_w0
xfeed_30506 1 0 decap_w0
xfeed_30505 1 0 decap_w0
xfeed_30504 1 0 decap_w0
xfeed_30503 1 0 decap_w0
xfeed_30502 1 0 decap_w0
xfeed_30501 1 0 decap_w0
xfeed_30500 1 0 decap_w0
xfeed_29349 1 0 decap_w0
xfeed_29348 1 0 decap_w0
xfeed_29347 1 0 decap_w0
xfeed_29346 1 0 decap_w0
xfeed_29345 1 0 decap_w0
xfeed_29344 1 0 decap_w0
xfeed_29343 1 0 decap_w0
xfeed_29342 1 0 decap_w0
xfeed_29341 1 0 decap_w0
xfeed_29340 1 0 decap_w0
xfeed_28819 1 0 decap_w0
xfeed_28818 1 0 decap_w0
xfeed_28817 1 0 decap_w0
xfeed_28816 1 0 decap_w0
xfeed_28815 1 0 decap_w0
xfeed_28814 1 0 decap_w0
xfeed_28813 1 0 decap_w0
xfeed_28812 1 0 decap_w0
xfeed_28811 1 0 decap_w0
xfeed_28810 1 0 decap_w0
xfeed_25039 1 0 decap_w0
xfeed_25038 1 0 decap_w0
xfeed_25037 1 0 decap_w0
xfeed_25036 1 0 decap_w0
xfeed_25035 1 0 decap_w0
xfeed_25034 1 0 decap_w0
xfeed_25033 1 0 decap_w0
xfeed_25032 1 0 decap_w0
xfeed_25031 1 0 decap_w0
xfeed_25030 1 0 decap_w0
xfeed_24509 1 0 decap_w0
xfeed_24508 1 0 decap_w0
xfeed_24507 1 0 decap_w0
xfeed_24506 1 0 decap_w0
xfeed_24505 1 0 decap_w0
xfeed_24504 1 0 decap_w0
xfeed_24503 1 0 decap_w0
xfeed_24502 1 0 decap_w0
xfeed_24501 1 0 decap_w0
xfeed_24500 1 0 decap_w0
xfeed_19033 1 0 decap_w0
xfeed_19032 1 0 decap_w0
xfeed_19031 1 0 decap_w0
xfeed_19030 1 0 decap_w0
xfeed_7379 1 0 decap_w0
xfeed_7378 1 0 decap_w0
xfeed_7377 1 0 decap_w0
xfeed_7376 1 0 decap_w0
xfeed_7375 1 0 decap_w0
xfeed_7374 1 0 decap_w0
xfeed_7373 1 0 decap_w0
xfeed_7372 1 0 decap_w0
xfeed_7371 1 0 decap_w0
xfeed_7370 1 0 decap_w0
xfeed_6849 1 0 decap_w0
xfeed_6848 1 0 decap_w0
xfeed_6847 1 0 decap_w0
xfeed_6846 1 0 decap_w0
xfeed_6845 1 0 decap_w0
xfeed_6844 1 0 decap_w0
xfeed_6843 1 0 decap_w0
xfeed_6842 1 0 decap_w0
xfeed_6841 1 0 decap_w0
xfeed_6840 1 0 decap_w0
xfeed_3069 1 0 decap_w0
xfeed_3068 1 0 decap_w0
xfeed_2539 1 0 decap_w0
xfeed_2538 1 0 decap_w0
xfeed_2537 1 0 decap_w0
xfeed_2536 1 0 decap_w0
xfeed_2535 1 0 decap_w0
xfeed_2534 1 0 decap_w0
xfeed_2533 1 0 decap_w0
xfeed_2532 1 0 decap_w0
xfeed_2531 1 0 decap_w0
xfeed_2530 1 0 decap_w0
xfeed_519 1 0 decap_w0
xfeed_518 1 0 decap_w0
xfeed_517 1 0 decap_w0
xfeed_516 1 0 decap_w0
xfeed_515 1 0 decap_w0
xfeed_514 1 0 decap_w0
xfeed_513 1 0 decap_w0
xfeed_512 1 0 decap_w0
xfeed_511 1 0 decap_w0
xfeed_510 1 0 decap_w0
xfeed_23899 1 0 decap_w0
xfeed_23898 1 0 decap_w0
xfeed_23897 1 0 decap_w0
xfeed_23896 1 0 decap_w0
xfeed_23895 1 0 decap_w0
xfeed_23894 1 0 decap_w0
xfeed_23893 1 0 decap_w0
xfeed_23892 1 0 decap_w0
xfeed_23891 1 0 decap_w0
xfeed_23890 1 0 decap_w0
xfeed_19039 1 0 decap_w0
xfeed_19038 1 0 decap_w0
xfeed_19037 1 0 decap_w0
xfeed_19036 1 0 decap_w0
xfeed_19035 1 0 decap_w0
xfeed_19034 1 0 decap_w0
xfeed_18509 1 0 decap_w0
xfeed_18508 1 0 decap_w0
xfeed_18507 1 0 decap_w0
xfeed_18506 1 0 decap_w0
xfeed_18505 1 0 decap_w0
xfeed_18504 1 0 decap_w0
xfeed_18503 1 0 decap_w0
xfeed_18502 1 0 decap_w0
xfeed_18501 1 0 decap_w0
xfeed_18500 1 0 decap_w0
xfeed_17899 1 0 decap_w0
xfeed_17898 1 0 decap_w0
xfeed_17897 1 0 decap_w0
xfeed_17896 1 0 decap_w0
xfeed_17895 1 0 decap_w0
xfeed_17894 1 0 decap_w0
xfeed_17893 1 0 decap_w0
xfeed_17892 1 0 decap_w0
xfeed_17891 1 0 decap_w0
xfeed_17890 1 0 decap_w0
xfeed_13589 1 0 decap_w0
xfeed_13588 1 0 decap_w0
xfeed_13587 1 0 decap_w0
xfeed_13586 1 0 decap_w0
xfeed_13585 1 0 decap_w0
xfeed_13584 1 0 decap_w0
xfeed_13583 1 0 decap_w0
xfeed_13582 1 0 decap_w0
xfeed_13581 1 0 decap_w0
xfeed_13580 1 0 decap_w0
xfeed_3074 1 0 decap_w0
xfeed_3073 1 0 decap_w0
xfeed_3072 1 0 decap_w0
xfeed_3071 1 0 decap_w0
xfeed_3070 1 0 decap_w0
xfeed_31049 1 0 decap_w0
xfeed_31048 1 0 decap_w0
xfeed_31047 1 0 decap_w0
xfeed_31046 1 0 decap_w0
xfeed_31045 1 0 decap_w0
xfeed_31044 1 0 decap_w0
xfeed_31043 1 0 decap_w0
xfeed_31042 1 0 decap_w0
xfeed_31041 1 0 decap_w0
xfeed_31040 1 0 decap_w0
xfeed_30519 1 0 decap_w0
xfeed_30518 1 0 decap_w0
xfeed_30517 1 0 decap_w0
xfeed_30516 1 0 decap_w0
xfeed_30515 1 0 decap_w0
xfeed_30514 1 0 decap_w0
xfeed_30513 1 0 decap_w0
xfeed_30512 1 0 decap_w0
xfeed_30511 1 0 decap_w0
xfeed_30510 1 0 decap_w0
xfeed_29359 1 0 decap_w0
xfeed_29358 1 0 decap_w0
xfeed_29357 1 0 decap_w0
xfeed_29356 1 0 decap_w0
xfeed_29355 1 0 decap_w0
xfeed_29354 1 0 decap_w0
xfeed_29353 1 0 decap_w0
xfeed_29352 1 0 decap_w0
xfeed_29351 1 0 decap_w0
xfeed_29350 1 0 decap_w0
xfeed_28828 1 0 decap_w0
xfeed_28827 1 0 decap_w0
xfeed_28826 1 0 decap_w0
xfeed_28825 1 0 decap_w0
xfeed_28824 1 0 decap_w0
xfeed_28823 1 0 decap_w0
xfeed_28822 1 0 decap_w0
xfeed_28821 1 0 decap_w0
xfeed_28820 1 0 decap_w0
xfeed_25049 1 0 decap_w0
xfeed_25048 1 0 decap_w0
xfeed_25047 1 0 decap_w0
xfeed_25046 1 0 decap_w0
xfeed_25045 1 0 decap_w0
xfeed_25044 1 0 decap_w0
xfeed_25043 1 0 decap_w0
xfeed_25042 1 0 decap_w0
xfeed_25041 1 0 decap_w0
xfeed_25040 1 0 decap_w0
xfeed_24519 1 0 decap_w0
xfeed_24518 1 0 decap_w0
xfeed_24517 1 0 decap_w0
xfeed_24516 1 0 decap_w0
xfeed_24515 1 0 decap_w0
xfeed_24514 1 0 decap_w0
xfeed_24513 1 0 decap_w0
xfeed_24512 1 0 decap_w0
xfeed_24511 1 0 decap_w0
xfeed_24510 1 0 decap_w0
xfeed_20209 1 0 decap_w0
xfeed_20208 1 0 decap_w0
xfeed_20207 1 0 decap_w0
xfeed_20206 1 0 decap_w0
xfeed_20205 1 0 decap_w0
xfeed_20204 1 0 decap_w0
xfeed_20203 1 0 decap_w0
xfeed_20202 1 0 decap_w0
xfeed_20201 1 0 decap_w0
xfeed_20200 1 0 decap_w0
xfeed_19040 1 0 decap_w0
xfeed_14201 1 0 decap_w0
xfeed_14200 1 0 decap_w0
xfeed_7389 1 0 decap_w0
xfeed_7388 1 0 decap_w0
xfeed_7387 1 0 decap_w0
xfeed_7386 1 0 decap_w0
xfeed_7385 1 0 decap_w0
xfeed_7384 1 0 decap_w0
xfeed_7383 1 0 decap_w0
xfeed_7382 1 0 decap_w0
xfeed_7381 1 0 decap_w0
xfeed_7380 1 0 decap_w0
xfeed_6859 1 0 decap_w0
xfeed_6858 1 0 decap_w0
xfeed_6857 1 0 decap_w0
xfeed_6856 1 0 decap_w0
xfeed_6855 1 0 decap_w0
xfeed_6854 1 0 decap_w0
xfeed_6853 1 0 decap_w0
xfeed_6852 1 0 decap_w0
xfeed_6851 1 0 decap_w0
xfeed_6850 1 0 decap_w0
xfeed_3079 1 0 decap_w0
xfeed_3078 1 0 decap_w0
xfeed_3077 1 0 decap_w0
xfeed_3076 1 0 decap_w0
xfeed_3075 1 0 decap_w0
xfeed_2549 1 0 decap_w0
xfeed_2548 1 0 decap_w0
xfeed_2547 1 0 decap_w0
xfeed_2546 1 0 decap_w0
xfeed_2545 1 0 decap_w0
xfeed_2544 1 0 decap_w0
xfeed_2543 1 0 decap_w0
xfeed_2542 1 0 decap_w0
xfeed_2541 1 0 decap_w0
xfeed_2540 1 0 decap_w0
xfeed_529 1 0 decap_w0
xfeed_528 1 0 decap_w0
xfeed_527 1 0 decap_w0
xfeed_526 1 0 decap_w0
xfeed_525 1 0 decap_w0
xfeed_524 1 0 decap_w0
xfeed_523 1 0 decap_w0
xfeed_522 1 0 decap_w0
xfeed_521 1 0 decap_w0
xfeed_520 1 0 decap_w0
xfeed_28829 1 0 decap_w0
xfeed_19049 1 0 decap_w0
xfeed_19048 1 0 decap_w0
xfeed_19047 1 0 decap_w0
xfeed_19046 1 0 decap_w0
xfeed_19045 1 0 decap_w0
xfeed_19044 1 0 decap_w0
xfeed_19043 1 0 decap_w0
xfeed_19042 1 0 decap_w0
xfeed_19041 1 0 decap_w0
xfeed_18519 1 0 decap_w0
xfeed_18518 1 0 decap_w0
xfeed_18517 1 0 decap_w0
xfeed_18516 1 0 decap_w0
xfeed_18515 1 0 decap_w0
xfeed_18514 1 0 decap_w0
xfeed_18513 1 0 decap_w0
xfeed_18512 1 0 decap_w0
xfeed_18511 1 0 decap_w0
xfeed_18510 1 0 decap_w0
xfeed_14209 1 0 decap_w0
xfeed_14208 1 0 decap_w0
xfeed_14207 1 0 decap_w0
xfeed_14206 1 0 decap_w0
xfeed_14205 1 0 decap_w0
xfeed_14204 1 0 decap_w0
xfeed_14203 1 0 decap_w0
xfeed_14202 1 0 decap_w0
xfeed_13599 1 0 decap_w0
xfeed_13598 1 0 decap_w0
xfeed_13597 1 0 decap_w0
xfeed_13596 1 0 decap_w0
xfeed_13595 1 0 decap_w0
xfeed_13594 1 0 decap_w0
xfeed_13593 1 0 decap_w0
xfeed_13592 1 0 decap_w0
xfeed_13591 1 0 decap_w0
xfeed_13590 1 0 decap_w0
xfeed_8009 1 0 decap_w0
xfeed_8008 1 0 decap_w0
xfeed_8007 1 0 decap_w0
xfeed_8006 1 0 decap_w0
xfeed_8005 1 0 decap_w0
xfeed_8004 1 0 decap_w0
xfeed_8003 1 0 decap_w0
xfeed_8002 1 0 decap_w0
xfeed_8001 1 0 decap_w0
xfeed_8000 1 0 decap_w0
xfeed_3081 1 0 decap_w0
xfeed_3080 1 0 decap_w0
xsubckt_1_inv_x0 1 0 138 3 inv_x0
xsubckt_3_inv_x0 1 0 137 25 inv_x0
xfeed_31059 1 0 decap_w0
xfeed_31058 1 0 decap_w0
xfeed_31057 1 0 decap_w0
xfeed_31056 1 0 decap_w0
xfeed_31055 1 0 decap_w0
xfeed_31054 1 0 decap_w0
xfeed_31053 1 0 decap_w0
xfeed_31052 1 0 decap_w0
xfeed_31051 1 0 decap_w0
xfeed_31050 1 0 decap_w0
xfeed_30529 1 0 decap_w0
xfeed_30528 1 0 decap_w0
xfeed_30527 1 0 decap_w0
xfeed_30526 1 0 decap_w0
xfeed_30525 1 0 decap_w0
xfeed_30524 1 0 decap_w0
xfeed_30523 1 0 decap_w0
xfeed_30522 1 0 decap_w0
xfeed_30521 1 0 decap_w0
xfeed_30520 1 0 decap_w0
xfeed_29369 1 0 decap_w0
xfeed_29368 1 0 decap_w0
xfeed_29367 1 0 decap_w0
xfeed_29366 1 0 decap_w0
xfeed_29365 1 0 decap_w0
xfeed_29364 1 0 decap_w0
xfeed_29363 1 0 decap_w0
xfeed_29362 1 0 decap_w0
xfeed_29361 1 0 decap_w0
xfeed_29360 1 0 decap_w0
xfeed_28835 1 0 decap_w0
xfeed_28834 1 0 decap_w0
xfeed_28833 1 0 decap_w0
xfeed_28832 1 0 decap_w0
xfeed_28831 1 0 decap_w0
xfeed_28830 1 0 decap_w0
xfeed_25059 1 0 decap_w0
xfeed_25058 1 0 decap_w0
xfeed_25057 1 0 decap_w0
xfeed_25056 1 0 decap_w0
xfeed_25055 1 0 decap_w0
xfeed_25054 1 0 decap_w0
xfeed_25053 1 0 decap_w0
xfeed_25052 1 0 decap_w0
xfeed_25051 1 0 decap_w0
xfeed_25050 1 0 decap_w0
xfeed_24529 1 0 decap_w0
xfeed_24528 1 0 decap_w0
xfeed_24527 1 0 decap_w0
xfeed_24526 1 0 decap_w0
xfeed_24525 1 0 decap_w0
xfeed_24524 1 0 decap_w0
xfeed_24523 1 0 decap_w0
xfeed_24522 1 0 decap_w0
xfeed_24521 1 0 decap_w0
xfeed_24520 1 0 decap_w0
xfeed_20219 1 0 decap_w0
xfeed_20218 1 0 decap_w0
xfeed_20217 1 0 decap_w0
xfeed_20216 1 0 decap_w0
xfeed_20215 1 0 decap_w0
xfeed_20214 1 0 decap_w0
xfeed_20213 1 0 decap_w0
xfeed_20212 1 0 decap_w0
xfeed_20211 1 0 decap_w0
xfeed_20210 1 0 decap_w0
xfeed_7399 1 0 decap_w0
xfeed_7398 1 0 decap_w0
xfeed_7397 1 0 decap_w0
xfeed_7396 1 0 decap_w0
xfeed_7395 1 0 decap_w0
xfeed_7394 1 0 decap_w0
xfeed_7393 1 0 decap_w0
xfeed_7392 1 0 decap_w0
xfeed_7391 1 0 decap_w0
xfeed_7390 1 0 decap_w0
xfeed_6869 1 0 decap_w0
xfeed_6868 1 0 decap_w0
xfeed_6867 1 0 decap_w0
xfeed_6866 1 0 decap_w0
xfeed_6865 1 0 decap_w0
xfeed_6864 1 0 decap_w0
xfeed_6863 1 0 decap_w0
xfeed_6862 1 0 decap_w0
xfeed_6861 1 0 decap_w0
xfeed_6860 1 0 decap_w0
xfeed_3089 1 0 decap_w0
xfeed_3088 1 0 decap_w0
xfeed_3087 1 0 decap_w0
xfeed_3086 1 0 decap_w0
xfeed_3085 1 0 decap_w0
xfeed_3084 1 0 decap_w0
xfeed_3083 1 0 decap_w0
xfeed_3082 1 0 decap_w0
xfeed_2559 1 0 decap_w0
xfeed_2558 1 0 decap_w0
xfeed_2557 1 0 decap_w0
xfeed_2556 1 0 decap_w0
xfeed_2555 1 0 decap_w0
xfeed_2554 1 0 decap_w0
xfeed_2553 1 0 decap_w0
xfeed_2552 1 0 decap_w0
xfeed_2551 1 0 decap_w0
xfeed_2550 1 0 decap_w0
xfeed_539 1 0 decap_w0
xfeed_538 1 0 decap_w0
xfeed_537 1 0 decap_w0
xfeed_536 1 0 decap_w0
xfeed_535 1 0 decap_w0
xfeed_534 1 0 decap_w0
xfeed_533 1 0 decap_w0
xfeed_532 1 0 decap_w0
xfeed_531 1 0 decap_w0
xfeed_530 1 0 decap_w0
xfeed_28839 1 0 decap_w0
xfeed_28838 1 0 decap_w0
xfeed_28837 1 0 decap_w0
xfeed_28836 1 0 decap_w0
xfeed_19059 1 0 decap_w0
xfeed_19058 1 0 decap_w0
xfeed_19057 1 0 decap_w0
xfeed_19056 1 0 decap_w0
xfeed_19055 1 0 decap_w0
xfeed_19054 1 0 decap_w0
xfeed_19053 1 0 decap_w0
xfeed_19052 1 0 decap_w0
xfeed_19051 1 0 decap_w0
xfeed_19050 1 0 decap_w0
xfeed_18529 1 0 decap_w0
xfeed_18528 1 0 decap_w0
xfeed_18527 1 0 decap_w0
xfeed_18526 1 0 decap_w0
xfeed_18524 1 0 decap_w0
xfeed_18523 1 0 decap_w0
xfeed_18522 1 0 decap_w0
xfeed_18521 1 0 decap_w0
xfeed_18520 1 0 decap_w0
xfeed_14219 1 0 decap_w0
xfeed_14218 1 0 decap_w0
xfeed_14217 1 0 decap_w0
xfeed_14216 1 0 decap_w0
xfeed_14215 1 0 decap_w0
xfeed_14214 1 0 decap_w0
xfeed_14213 1 0 decap_w0
xfeed_14212 1 0 decap_w0
xfeed_14211 1 0 decap_w0
xfeed_14210 1 0 decap_w0
xfeed_8019 1 0 decap_w0
xfeed_8018 1 0 decap_w0
xfeed_8017 1 0 decap_w0
xfeed_8016 1 0 decap_w0
xfeed_8015 1 0 decap_w0
xfeed_8014 1 0 decap_w0
xfeed_8013 1 0 decap_w0
xfeed_8012 1 0 decap_w0
xfeed_8011 1 0 decap_w0
xfeed_8010 1 0 decap_w0
xfeed_31069 1 0 decap_w0
xfeed_31068 1 0 decap_w0
xfeed_31067 1 0 decap_w0
xfeed_31066 1 0 decap_w0
xfeed_31065 1 0 decap_w0
xfeed_31064 1 0 decap_w0
xfeed_31063 1 0 decap_w0
xfeed_31062 1 0 decap_w0
xfeed_31061 1 0 decap_w0
xfeed_31060 1 0 decap_w0
xfeed_30539 1 0 decap_w0
xfeed_30538 1 0 decap_w0
xfeed_30537 1 0 decap_w0
xfeed_30536 1 0 decap_w0
xfeed_30535 1 0 decap_w0
xfeed_30534 1 0 decap_w0
xfeed_30533 1 0 decap_w0
xfeed_30532 1 0 decap_w0
xfeed_30531 1 0 decap_w0
xfeed_30530 1 0 decap_w0
xfeed_29379 1 0 decap_w0
xfeed_29378 1 0 decap_w0
xfeed_29377 1 0 decap_w0
xfeed_29376 1 0 decap_w0
xfeed_29375 1 0 decap_w0
xfeed_29374 1 0 decap_w0
xfeed_29373 1 0 decap_w0
xfeed_29372 1 0 decap_w0
xfeed_29371 1 0 decap_w0
xfeed_29370 1 0 decap_w0
xfeed_28842 1 0 decap_w0
xfeed_28841 1 0 decap_w0
xfeed_28840 1 0 decap_w0
xfeed_25069 1 0 decap_w0
xfeed_25068 1 0 decap_w0
xfeed_25067 1 0 decap_w0
xfeed_25066 1 0 decap_w0
xfeed_25065 1 0 decap_w0
xfeed_25064 1 0 decap_w0
xfeed_25063 1 0 decap_w0
xfeed_25062 1 0 decap_w0
xfeed_25061 1 0 decap_w0
xfeed_25060 1 0 decap_w0
xfeed_24539 1 0 decap_w0
xfeed_24538 1 0 decap_w0
xfeed_24537 1 0 decap_w0
xfeed_24536 1 0 decap_w0
xfeed_24535 1 0 decap_w0
xfeed_24534 1 0 decap_w0
xfeed_24533 1 0 decap_w0
xfeed_24532 1 0 decap_w0
xfeed_24531 1 0 decap_w0
xfeed_24530 1 0 decap_w0
xfeed_20229 1 0 decap_w0
xfeed_20228 1 0 decap_w0
xfeed_20227 1 0 decap_w0
xfeed_20226 1 0 decap_w0
xfeed_20225 1 0 decap_w0
xfeed_20224 1 0 decap_w0
xfeed_20223 1 0 decap_w0
xfeed_20222 1 0 decap_w0
xfeed_20221 1 0 decap_w0
xfeed_20220 1 0 decap_w0
xfeed_6879 1 0 decap_w0
xfeed_6878 1 0 decap_w0
xfeed_6877 1 0 decap_w0
xfeed_6876 1 0 decap_w0
xfeed_6875 1 0 decap_w0
xfeed_6874 1 0 decap_w0
xfeed_6873 1 0 decap_w0
xfeed_6872 1 0 decap_w0
xfeed_6871 1 0 decap_w0
xfeed_6870 1 0 decap_w0
xfeed_3099 1 0 decap_w0
xfeed_3098 1 0 decap_w0
xfeed_3097 1 0 decap_w0
xfeed_3096 1 0 decap_w0
xfeed_3095 1 0 decap_w0
xfeed_3094 1 0 decap_w0
xfeed_3093 1 0 decap_w0
xfeed_3092 1 0 decap_w0
xfeed_3091 1 0 decap_w0
xfeed_3090 1 0 decap_w0
xfeed_2569 1 0 decap_w0
xfeed_2568 1 0 decap_w0
xfeed_2567 1 0 decap_w0
xfeed_2566 1 0 decap_w0
xfeed_2565 1 0 decap_w0
xfeed_2564 1 0 decap_w0
xfeed_2563 1 0 decap_w0
xfeed_2562 1 0 decap_w0
xfeed_2561 1 0 decap_w0
xfeed_2560 1 0 decap_w0
xfeed_549 1 0 decap_w0
xfeed_548 1 0 decap_w0
xfeed_547 1 0 decap_w0
xfeed_546 1 0 decap_w0
xfeed_545 1 0 decap_w0
xfeed_544 1 0 decap_w0
xfeed_543 1 0 decap_w0
xfeed_542 1 0 decap_w0
xfeed_541 1 0 decap_w0
xfeed_540 1 0 decap_w0
xfeed_28849 1 0 decap_w0
xfeed_28848 1 0 decap_w0
xfeed_28847 1 0 decap_w0
xfeed_28846 1 0 decap_w0
xfeed_28845 1 0 decap_w0
xfeed_28844 1 0 decap_w0
xfeed_28843 1 0 decap_w0
xfeed_19069 1 0 decap_w0
xfeed_19068 1 0 decap_w0
xfeed_19067 1 0 decap_w0
xfeed_19066 1 0 decap_w0
xfeed_19065 1 0 decap_w0
xfeed_19064 1 0 decap_w0
xfeed_19063 1 0 decap_w0
xfeed_19062 1 0 decap_w0
xfeed_19061 1 0 decap_w0
xfeed_19060 1 0 decap_w0
xfeed_18539 1 0 decap_w0
xfeed_18538 1 0 decap_w0
xfeed_18537 1 0 decap_w0
xfeed_18536 1 0 decap_w0
xfeed_18535 1 0 decap_w0
xfeed_18534 1 0 decap_w0
xfeed_18533 1 0 decap_w0
xfeed_18532 1 0 decap_w0
xfeed_18531 1 0 decap_w0
xfeed_18530 1 0 decap_w0
xfeed_14229 1 0 decap_w0
xfeed_14228 1 0 decap_w0
xfeed_14227 1 0 decap_w0
xfeed_14226 1 0 decap_w0
xfeed_14225 1 0 decap_w0
xfeed_14224 1 0 decap_w0
xfeed_14223 1 0 decap_w0
xfeed_14222 1 0 decap_w0
xfeed_14221 1 0 decap_w0
xfeed_14220 1 0 decap_w0
xfeed_8029 1 0 decap_w0
xfeed_8028 1 0 decap_w0
xfeed_8027 1 0 decap_w0
xfeed_8026 1 0 decap_w0
xfeed_8025 1 0 decap_w0
xfeed_8024 1 0 decap_w0
xfeed_8023 1 0 decap_w0
xfeed_8022 1 0 decap_w0
xfeed_8021 1 0 decap_w0
xfeed_8020 1 0 decap_w0
xfeed_31079 1 0 decap_w0
xfeed_31078 1 0 decap_w0
xfeed_31077 1 0 decap_w0
xfeed_31076 1 0 decap_w0
xfeed_31075 1 0 decap_w0
xfeed_31074 1 0 decap_w0
xfeed_31073 1 0 decap_w0
xfeed_31072 1 0 decap_w0
xfeed_31071 1 0 decap_w0
xfeed_31070 1 0 decap_w0
xfeed_30549 1 0 decap_w0
xfeed_30548 1 0 decap_w0
xfeed_30547 1 0 decap_w0
xfeed_30546 1 0 decap_w0
xfeed_30545 1 0 decap_w0
xfeed_30544 1 0 decap_w0
xfeed_30543 1 0 decap_w0
xfeed_30542 1 0 decap_w0
xfeed_30541 1 0 decap_w0
xfeed_30540 1 0 decap_w0
xfeed_29388 1 0 decap_w0
xfeed_29387 1 0 decap_w0
xfeed_29386 1 0 decap_w0
xfeed_29385 1 0 decap_w0
xfeed_29384 1 0 decap_w0
xfeed_29383 1 0 decap_w0
xfeed_29382 1 0 decap_w0
xfeed_29381 1 0 decap_w0
xfeed_29380 1 0 decap_w0
xfeed_25079 1 0 decap_w0
xfeed_25078 1 0 decap_w0
xfeed_25077 1 0 decap_w0
xfeed_25076 1 0 decap_w0
xfeed_25075 1 0 decap_w0
xfeed_25074 1 0 decap_w0
xfeed_25073 1 0 decap_w0
xfeed_25072 1 0 decap_w0
xfeed_25071 1 0 decap_w0
xfeed_25070 1 0 decap_w0
xfeed_24549 1 0 decap_w0
xfeed_24548 1 0 decap_w0
xfeed_24547 1 0 decap_w0
xfeed_24546 1 0 decap_w0
xfeed_24545 1 0 decap_w0
xfeed_24544 1 0 decap_w0
xfeed_24543 1 0 decap_w0
xfeed_24542 1 0 decap_w0
xfeed_24541 1 0 decap_w0
xfeed_24540 1 0 decap_w0
xfeed_20239 1 0 decap_w0
xfeed_20238 1 0 decap_w0
xfeed_20237 1 0 decap_w0
xfeed_20236 1 0 decap_w0
xfeed_20235 1 0 decap_w0
xfeed_20234 1 0 decap_w0
xfeed_20233 1 0 decap_w0
xfeed_20232 1 0 decap_w0
xfeed_20231 1 0 decap_w0
xfeed_20230 1 0 decap_w0
xfeed_6889 1 0 decap_w0
xfeed_6888 1 0 decap_w0
xfeed_6887 1 0 decap_w0
xfeed_6886 1 0 decap_w0
xfeed_6885 1 0 decap_w0
xfeed_6884 1 0 decap_w0
xfeed_6883 1 0 decap_w0
xfeed_6882 1 0 decap_w0
xfeed_6881 1 0 decap_w0
xfeed_6880 1 0 decap_w0
xfeed_2579 1 0 decap_w0
xfeed_2578 1 0 decap_w0
xfeed_2577 1 0 decap_w0
xfeed_2576 1 0 decap_w0
xfeed_2575 1 0 decap_w0
xfeed_2574 1 0 decap_w0
xfeed_2573 1 0 decap_w0
xfeed_2572 1 0 decap_w0
xfeed_2571 1 0 decap_w0
xfeed_2570 1 0 decap_w0
xfeed_559 1 0 decap_w0
xfeed_558 1 0 decap_w0
xfeed_557 1 0 decap_w0
xfeed_556 1 0 decap_w0
xfeed_555 1 0 decap_w0
xfeed_554 1 0 decap_w0
xfeed_553 1 0 decap_w0
xfeed_552 1 0 decap_w0
xfeed_551 1 0 decap_w0
xfeed_550 1 0 decap_w0
xsubckt_84_xor2_x0 1 0 46 55 151 xor2_x0
xfeed_29389 1 0 decap_w0
xfeed_28859 1 0 decap_w0
xfeed_28858 1 0 decap_w0
xfeed_28857 1 0 decap_w0
xfeed_28856 1 0 decap_w0
xfeed_28855 1 0 decap_w0
xfeed_28854 1 0 decap_w0
xfeed_28853 1 0 decap_w0
xfeed_28852 1 0 decap_w0
xfeed_28851 1 0 decap_w0
xfeed_28850 1 0 decap_w0
xfeed_19079 1 0 decap_w0
xfeed_19078 1 0 decap_w0
xfeed_19077 1 0 decap_w0
xfeed_19076 1 0 decap_w0
xfeed_19075 1 0 decap_w0
xfeed_19074 1 0 decap_w0
xfeed_19073 1 0 decap_w0
xfeed_19072 1 0 decap_w0
xfeed_19071 1 0 decap_w0
xfeed_19070 1 0 decap_w0
xfeed_18549 1 0 decap_w0
xfeed_18548 1 0 decap_w0
xfeed_18547 1 0 decap_w0
xfeed_18546 1 0 decap_w0
xfeed_18545 1 0 decap_w0
xfeed_18544 1 0 decap_w0
xfeed_18543 1 0 decap_w0
xfeed_18542 1 0 decap_w0
xfeed_18541 1 0 decap_w0
xfeed_18540 1 0 decap_w0
xfeed_14239 1 0 decap_w0
xfeed_14238 1 0 decap_w0
xfeed_14237 1 0 decap_w0
xfeed_14236 1 0 decap_w0
xfeed_14235 1 0 tie
xfeed_14234 1 0 decap_w0
xfeed_14233 1 0 decap_w0
xfeed_14232 1 0 decap_w0
xfeed_14231 1 0 decap_w0
xfeed_14230 1 0 decap_w0
xfeed_13709 1 0 decap_w0
xfeed_13708 1 0 decap_w0
xfeed_13707 1 0 decap_w0
xfeed_13706 1 0 decap_w0
xfeed_13705 1 0 decap_w0
xfeed_13704 1 0 decap_w0
xfeed_13703 1 0 decap_w0
xfeed_13702 1 0 decap_w0
xfeed_13701 1 0 decap_w0
xfeed_13700 1 0 decap_w0
xfeed_8039 1 0 decap_w0
xfeed_8038 1 0 decap_w0
xfeed_8037 1 0 decap_w0
xfeed_8036 1 0 decap_w0
xfeed_8035 1 0 decap_w0
xfeed_8034 1 0 decap_w0
xfeed_8033 1 0 decap_w0
xfeed_8032 1 0 decap_w0
xfeed_8031 1 0 decap_w0
xfeed_8030 1 0 decap_w0
xfeed_7500 1 0 decap_w0
xfeed_31089 1 0 decap_w0
xfeed_31088 1 0 decap_w0
xfeed_31087 1 0 decap_w0
xfeed_31086 1 0 decap_w0
xfeed_31085 1 0 decap_w0
xfeed_31084 1 0 decap_w0
xfeed_31083 1 0 decap_w0
xfeed_31082 1 0 decap_w0
xfeed_31081 1 0 decap_w0
xfeed_31080 1 0 decap_w0
xfeed_30559 1 0 decap_w0
xfeed_30558 1 0 decap_w0
xfeed_30557 1 0 decap_w0
xfeed_30556 1 0 decap_w0
xfeed_30555 1 0 decap_w0
xfeed_30554 1 0 decap_w0
xfeed_30553 1 0 decap_w0
xfeed_30552 1 0 decap_w0
xfeed_30551 1 0 decap_w0
xfeed_30550 1 0 decap_w0
xfeed_29395 1 0 decap_w0
xfeed_29394 1 0 decap_w0
xfeed_29393 1 0 decap_w0
xfeed_29392 1 0 decap_w0
xfeed_29391 1 0 decap_w0
xfeed_29390 1 0 decap_w0
xfeed_25089 1 0 decap_w0
xfeed_25088 1 0 decap_w0
xfeed_25087 1 0 decap_w0
xfeed_25086 1 0 decap_w0
xfeed_25085 1 0 decap_w0
xfeed_25084 1 0 decap_w0
xfeed_25083 1 0 decap_w0
xfeed_25082 1 0 decap_w0
xfeed_25081 1 0 decap_w0
xfeed_25080 1 0 decap_w0
xfeed_24556 1 0 decap_w0
xfeed_24555 1 0 decap_w0
xfeed_24554 1 0 decap_w0
xfeed_24553 1 0 decap_w0
xfeed_24552 1 0 decap_w0
xfeed_24551 1 0 decap_w0
xfeed_24550 1 0 decap_w0
xfeed_20249 1 0 decap_w0
xfeed_20248 1 0 decap_w0
xfeed_20247 1 0 decap_w0
xfeed_20246 1 0 decap_w0
xfeed_20245 1 0 decap_w0
xfeed_20244 1 0 decap_w0
xfeed_20243 1 0 decap_w0
xfeed_20242 1 0 decap_w0
xfeed_20241 1 0 decap_w0
xfeed_20240 1 0 decap_w0
xfeed_7509 1 0 decap_w0
xfeed_7508 1 0 decap_w0
xfeed_7507 1 0 decap_w0
xfeed_7506 1 0 decap_w0
xfeed_7505 1 0 decap_w0
xfeed_7504 1 0 decap_w0
xfeed_7503 1 0 decap_w0
xfeed_7502 1 0 decap_w0
xfeed_7501 1 0 decap_w0
xfeed_6899 1 0 decap_w0
xfeed_6898 1 0 decap_w0
xfeed_6897 1 0 decap_w0
xfeed_6896 1 0 decap_w0
xfeed_6895 1 0 decap_w0
xfeed_6894 1 0 decap_w0
xfeed_6893 1 0 decap_w0
xfeed_6892 1 0 decap_w0
xfeed_6891 1 0 decap_w0
xfeed_6890 1 0 decap_w0
xfeed_2589 1 0 decap_w0
xfeed_2588 1 0 decap_w0
xfeed_2587 1 0 decap_w0
xfeed_2586 1 0 decap_w0
xfeed_2585 1 0 decap_w0
xfeed_2584 1 0 decap_w0
xfeed_2583 1 0 decap_w0
xfeed_2582 1 0 decap_w0
xfeed_2581 1 0 decap_w0
xfeed_2580 1 0 decap_w0
xfeed_569 1 0 decap_w0
xfeed_568 1 0 decap_w0
xfeed_567 1 0 decap_w0
xfeed_566 1 0 decap_w0
xfeed_565 1 0 decap_w0
xfeed_564 1 0 decap_w0
xfeed_563 1 0 decap_w0
xfeed_562 1 0 decap_w0
xfeed_561 1 0 decap_w0
xfeed_560 1 0 decap_w0
xfeed_29399 1 0 decap_w0
xfeed_29398 1 0 decap_w0
xfeed_29397 1 0 decap_w0
xfeed_29396 1 0 decap_w0
xfeed_28869 1 0 decap_w0
xfeed_28868 1 0 decap_w0
xfeed_28867 1 0 decap_w0
xfeed_28866 1 0 decap_w0
xfeed_28865 1 0 decap_w0
xfeed_28864 1 0 decap_w0
xfeed_28863 1 0 decap_w0
xfeed_28862 1 0 decap_w0
xfeed_28861 1 0 decap_w0
xfeed_28860 1 0 decap_w0
xfeed_24559 1 0 decap_w0
xfeed_24558 1 0 decap_w0
xfeed_24557 1 0 decap_w0
xfeed_19089 1 0 decap_w0
xfeed_19088 1 0 decap_w0
xfeed_19087 1 0 decap_w0
xfeed_19086 1 0 decap_w0
xfeed_19085 1 0 decap_w0
xfeed_19084 1 0 decap_w0
xfeed_19083 1 0 decap_w0
xfeed_19082 1 0 decap_w0
xfeed_19081 1 0 decap_w0
xfeed_19080 1 0 decap_w0
xfeed_18559 1 0 decap_w0
xfeed_18558 1 0 decap_w0
xfeed_18557 1 0 decap_w0
xfeed_18556 1 0 decap_w0
xfeed_18555 1 0 decap_w0
xfeed_18554 1 0 decap_w0
xfeed_18553 1 0 decap_w0
xfeed_18552 1 0 decap_w0
xfeed_18551 1 0 decap_w0
xfeed_18550 1 0 decap_w0
xfeed_14249 1 0 decap_w0
xfeed_14248 1 0 decap_w0
xfeed_14247 1 0 decap_w0
xfeed_14246 1 0 decap_w0
xfeed_14245 1 0 decap_w0
xfeed_14244 1 0 decap_w0
xfeed_14243 1 0 decap_w0
xfeed_14242 1 0 decap_w0
xfeed_14241 1 0 decap_w0
xfeed_14240 1 0 decap_w0
xfeed_13719 1 0 decap_w0
xfeed_13718 1 0 decap_w0
xfeed_13717 1 0 decap_w0
xfeed_13716 1 0 decap_w0
xfeed_13715 1 0 decap_w0
xfeed_13714 1 0 decap_w0
xfeed_13713 1 0 decap_w0
xfeed_13712 1 0 decap_w0
xfeed_13711 1 0 decap_w0
xfeed_13710 1 0 decap_w0
xfeed_8046 1 0 decap_w0
xfeed_8045 1 0 decap_w0
xfeed_8044 1 0 decap_w0
xfeed_8043 1 0 decap_w0
xfeed_8042 1 0 decap_w0
xfeed_8041 1 0 decap_w0
xfeed_8040 1 0 decap_w0
xfeed_3207 1 0 decap_w0
xfeed_3206 1 0 decap_w0
xfeed_3205 1 0 decap_w0
xfeed_3204 1 0 decap_w0
xfeed_3203 1 0 decap_w0
xfeed_3202 1 0 decap_w0
xfeed_3201 1 0 decap_w0
xfeed_3200 1 0 decap_w0
xsubckt_13_inv_x0 1 0 131 20 inv_x0
xfeed_31099 1 0 decap_w0
xfeed_31098 1 0 decap_w0
xfeed_31097 1 0 decap_w0
xfeed_31096 1 0 decap_w0
xfeed_31095 1 0 decap_w0
xfeed_31094 1 0 decap_w0
xfeed_31093 1 0 decap_w0
xfeed_31092 1 0 decap_w0
xfeed_31091 1 0 decap_w0
xfeed_31090 1 0 decap_w0
xfeed_30569 1 0 decap_w0
xfeed_30568 1 0 decap_w0
xfeed_30567 1 0 decap_w0
xfeed_30566 1 0 decap_w0
xfeed_30565 1 0 decap_w0
xfeed_30564 1 0 decap_w0
xfeed_30563 1 0 decap_w0
xfeed_30562 1 0 decap_w0
xfeed_30561 1 0 decap_w0
xfeed_30560 1 0 decap_w0
xfeed_25099 1 0 decap_w0
xfeed_25098 1 0 decap_w0
xfeed_25097 1 0 decap_w0
xfeed_25096 1 0 decap_w0
xfeed_25095 1 0 decap_w0
xfeed_25094 1 0 decap_w0
xfeed_25093 1 0 decap_w0
xfeed_25092 1 0 decap_w0
xfeed_25091 1 0 decap_w0
xfeed_25090 1 0 decap_w0
xfeed_24563 1 0 decap_w0
xfeed_24562 1 0 decap_w0
xfeed_24561 1 0 decap_w0
xfeed_24560 1 0 decap_w0
xfeed_20259 1 0 decap_w0
xfeed_20258 1 0 decap_w0
xfeed_20257 1 0 decap_w0
xfeed_20256 1 0 decap_w0
xfeed_20255 1 0 decap_w0
xfeed_20254 1 0 decap_w0
xfeed_20253 1 0 decap_w0
xfeed_20252 1 0 decap_w0
xfeed_20251 1 0 decap_w0
xfeed_20250 1 0 decap_w0
xfeed_8049 1 0 decap_w0
xfeed_8048 1 0 tie
xfeed_8047 1 0 decap_w0
xfeed_7519 1 0 decap_w0
xfeed_7518 1 0 decap_w0
xfeed_7517 1 0 decap_w0
xfeed_7516 1 0 decap_w0
xfeed_7515 1 0 decap_w0
xfeed_7514 1 0 decap_w0
xfeed_7513 1 0 decap_w0
xfeed_7512 1 0 decap_w0
xfeed_7511 1 0 decap_w0
xfeed_7510 1 0 decap_w0
xfeed_3209 1 0 decap_w0
xfeed_3208 1 0 decap_w0
xfeed_2599 1 0 decap_w0
xfeed_2598 1 0 decap_w0
xfeed_2597 1 0 decap_w0
xfeed_2596 1 0 decap_w0
xfeed_2595 1 0 decap_w0
xfeed_2594 1 0 decap_w0
xfeed_2593 1 0 decap_w0
xfeed_2592 1 0 decap_w0
xfeed_2591 1 0 decap_w0
xfeed_2590 1 0 decap_w0
xfeed_576 1 0 decap_w0
xfeed_575 1 0 decap_w0
xfeed_574 1 0 decap_w0
xfeed_573 1 0 decap_w0
xfeed_572 1 0 decap_w0
xfeed_571 1 0 decap_w0
xfeed_570 1 0 decap_w0
xfeed_28879 1 0 decap_w0
xfeed_28878 1 0 decap_w0
xfeed_28877 1 0 decap_w0
xfeed_28876 1 0 decap_w0
xfeed_28875 1 0 decap_w0
xfeed_28874 1 0 decap_w0
xfeed_28873 1 0 decap_w0
xfeed_28872 1 0 decap_w0
xfeed_28871 1 0 decap_w0
xfeed_28870 1 0 decap_w0
xfeed_24569 1 0 decap_w0
xfeed_24568 1 0 decap_w0
xfeed_24567 1 0 decap_w0
xfeed_24566 1 0 decap_w0
xfeed_24565 1 0 decap_w0
xfeed_24564 1 0 decap_w0
xfeed_19099 1 0 decap_w0
xfeed_19098 1 0 decap_w0
xfeed_19097 1 0 decap_w0
xfeed_19096 1 0 decap_w0
xfeed_19095 1 0 decap_w0
xfeed_19094 1 0 decap_w0
xfeed_19093 1 0 decap_w0
xfeed_19092 1 0 decap_w0
xfeed_19091 1 0 decap_w0
xfeed_19090 1 0 decap_w0
xfeed_18569 1 0 decap_w0
xfeed_18568 1 0 decap_w0
xfeed_18567 1 0 decap_w0
xfeed_18566 1 0 decap_w0
xfeed_18565 1 0 decap_w0
xfeed_18564 1 0 decap_w0
xfeed_18563 1 0 decap_w0
xfeed_18562 1 0 decap_w0
xfeed_18561 1 0 decap_w0
xfeed_18560 1 0 decap_w0
xfeed_14259 1 0 decap_w0
xfeed_14258 1 0 decap_w0
xfeed_14257 1 0 decap_w0
xfeed_14256 1 0 decap_w0
xfeed_14255 1 0 decap_w0
xfeed_14254 1 0 decap_w0
xfeed_14253 1 0 decap_w0
xfeed_14252 1 0 decap_w0
xfeed_14251 1 0 decap_w0
xfeed_14250 1 0 decap_w0
xfeed_13729 1 0 decap_w0
xfeed_13728 1 0 decap_w0
xfeed_13727 1 0 decap_w0
xfeed_13726 1 0 decap_w0
xfeed_13725 1 0 decap_w0
xfeed_13724 1 0 decap_w0
xfeed_13723 1 0 decap_w0
xfeed_13722 1 0 decap_w0
xfeed_13721 1 0 decap_w0
xfeed_13720 1 0 decap_w0
xfeed_8053 1 0 decap_w0
xfeed_8052 1 0 decap_w0
xfeed_8051 1 0 decap_w0
xfeed_8050 1 0 decap_w0
xfeed_3214 1 0 decap_w0
xfeed_3213 1 0 decap_w0
xfeed_3212 1 0 decap_w0
xfeed_3211 1 0 decap_w0
xfeed_3210 1 0 decap_w0
xfeed_579 1 0 decap_w0
xfeed_578 1 0 decap_w0
xfeed_577 1 0 decap_w0
xfeed_30579 1 0 decap_w0
xfeed_30578 1 0 decap_w0
xfeed_30577 1 0 decap_w0
xfeed_30576 1 0 decap_w0
xfeed_30575 1 0 decap_w0
xfeed_30574 1 0 decap_w0
xfeed_30573 1 0 decap_w0
xfeed_30572 1 0 decap_w0
xfeed_30571 1 0 decap_w0
xfeed_30570 1 0 decap_w0
xfeed_24570 1 0 decap_w0
xfeed_20269 1 0 decap_w0
xfeed_20268 1 0 decap_w0
xfeed_20267 1 0 decap_w0
xfeed_20266 1 0 decap_w0
xfeed_20265 1 0 decap_w0
xfeed_20264 1 0 decap_w0
xfeed_20263 1 0 decap_w0
xfeed_20262 1 0 decap_w0
xfeed_20261 1 0 decap_w0
xfeed_20260 1 0 decap_w0
xfeed_8059 1 0 decap_w0
xfeed_8058 1 0 decap_w0
xfeed_8057 1 0 decap_w0
xfeed_8056 1 0 decap_w0
xfeed_8055 1 0 decap_w0
xfeed_8054 1 0 decap_w0
xfeed_7529 1 0 decap_w0
xfeed_7528 1 0 decap_w0
xfeed_7527 1 0 decap_w0
xfeed_7526 1 0 decap_w0
xfeed_7525 1 0 decap_w0
xfeed_7524 1 0 decap_w0
xfeed_7523 1 0 decap_w0
xfeed_7522 1 0 decap_w0
xfeed_7521 1 0 decap_w0
xfeed_7520 1 0 decap_w0
xfeed_3219 1 0 decap_w0
xfeed_3218 1 0 decap_w0
xfeed_3217 1 0 decap_w0
xfeed_3216 1 0 decap_w0
xfeed_3215 1 0 decap_w0
xfeed_583 1 0 decap_w0
xfeed_582 1 0 decap_w0
xfeed_581 1 0 decap_w0
xfeed_580 1 0 decap_w0
xfeed_28889 1 0 decap_w0
xfeed_28888 1 0 decap_w0
xfeed_28887 1 0 decap_w0
xfeed_28886 1 0 decap_w0
xfeed_28885 1 0 decap_w0
xfeed_28884 1 0 decap_w0
xfeed_28883 1 0 decap_w0
xfeed_28882 1 0 decap_w0
xfeed_28881 1 0 decap_w0
xfeed_28880 1 0 decap_w0
xfeed_24579 1 0 decap_w0
xfeed_24578 1 0 decap_w0
xfeed_24577 1 0 decap_w0
xfeed_24576 1 0 decap_w0
xfeed_24575 1 0 decap_w0
xfeed_24574 1 0 decap_w0
xfeed_24573 1 0 decap_w0
xfeed_24572 1 0 decap_w0
xfeed_24571 1 0 decap_w0
xfeed_18579 1 0 decap_w0
xfeed_18578 1 0 decap_w0
xfeed_18577 1 0 decap_w0
xfeed_18576 1 0 decap_w0
xfeed_18575 1 0 decap_w0
xfeed_18574 1 0 decap_w0
xfeed_18573 1 0 decap_w0
xfeed_18572 1 0 decap_w0
xfeed_18571 1 0 decap_w0
xfeed_18570 1 0 decap_w0
xfeed_14269 1 0 decap_w0
xfeed_14268 1 0 decap_w0
xfeed_14267 1 0 decap_w0
xfeed_14266 1 0 decap_w0
xfeed_14265 1 0 decap_w0
xfeed_14264 1 0 decap_w0
xfeed_14263 1 0 decap_w0
xfeed_14262 1 0 decap_w0
xfeed_14261 1 0 decap_w0
xfeed_14260 1 0 decap_w0
xfeed_13739 1 0 decap_w0
xfeed_13738 1 0 decap_w0
xfeed_13737 1 0 decap_w0
xfeed_13736 1 0 decap_w0
xfeed_13735 1 0 decap_w0
xfeed_13734 1 0 decap_w0
xfeed_13733 1 0 decap_w0
xfeed_13732 1 0 decap_w0
xfeed_13731 1 0 decap_w0
xfeed_13730 1 0 decap_w0
xfeed_8060 1 0 decap_w0
xfeed_3221 1 0 decap_w0
xfeed_3220 1 0 decap_w0
xfeed_589 1 0 decap_w0
xfeed_588 1 0 decap_w0
xfeed_587 1 0 decap_w0
xfeed_586 1 0 decap_w0
xfeed_585 1 0 decap_w0
xfeed_584 1 0 decap_w0
xfeed_30589 1 0 decap_w0
xfeed_30588 1 0 decap_w0
xfeed_30587 1 0 decap_w0
xfeed_30586 1 0 decap_w0
xfeed_30585 1 0 decap_w0
xfeed_30584 1 0 decap_w0
xfeed_30583 1 0 decap_w0
xfeed_30582 1 0 decap_w0
xfeed_30581 1 0 decap_w0
xfeed_30580 1 0 decap_w0
xfeed_29509 1 0 decap_w0
xfeed_29508 1 0 decap_w0
xfeed_29507 1 0 decap_w0
xfeed_29506 1 0 decap_w0
xfeed_29505 1 0 decap_w0
xfeed_29504 1 0 decap_w0
xfeed_29503 1 0 decap_w0
xfeed_29502 1 0 decap_w0
xfeed_29501 1 0 decap_w0
xfeed_29500 1 0 decap_w0
xfeed_20277 1 0 decap_w0
xfeed_20276 1 0 decap_w0
xfeed_20275 1 0 decap_w0
xfeed_20274 1 0 decap_w0
xfeed_20273 1 0 decap_w0
xfeed_20272 1 0 decap_w0
xfeed_20271 1 0 decap_w0
xfeed_20270 1 0 decap_w0
xfeed_8069 1 0 decap_w0
xfeed_8068 1 0 decap_w0
xfeed_8067 1 0 decap_w0
xfeed_8066 1 0 decap_w0
xfeed_8065 1 0 decap_w0
xfeed_8064 1 0 decap_w0
xfeed_8063 1 0 decap_w0
xfeed_8062 1 0 decap_w0
xfeed_8061 1 0 decap_w0
xfeed_7539 1 0 decap_w0
xfeed_7538 1 0 decap_w0
xfeed_7537 1 0 decap_w0
xfeed_7536 1 0 decap_w0
xfeed_7535 1 0 decap_w0
xfeed_7534 1 0 decap_w0
xfeed_7533 1 0 decap_w0
xfeed_7532 1 0 decap_w0
xfeed_7531 1 0 decap_w0
xfeed_7530 1 0 decap_w0
xfeed_3229 1 0 decap_w0
xfeed_3228 1 0 decap_w0
xfeed_3227 1 0 decap_w0
xfeed_3226 1 0 decap_w0
xfeed_3225 1 0 decap_w0
xfeed_3224 1 0 decap_w0
xfeed_3223 1 0 decap_w0
xfeed_3222 1 0 decap_w0
xfeed_590 1 0 decap_w0
xfeed_28899 1 0 decap_w0
xfeed_28898 1 0 decap_w0
xfeed_28897 1 0 decap_w0
xfeed_28896 1 0 decap_w0
xfeed_28895 1 0 decap_w0
xfeed_28894 1 0 decap_w0
xfeed_28893 1 0 decap_w0
xfeed_28892 1 0 decap_w0
xfeed_28891 1 0 decap_w0
xfeed_28890 1 0 decap_w0
xfeed_24589 1 0 decap_w0
xfeed_24588 1 0 decap_w0
xfeed_24587 1 0 decap_w0
xfeed_24586 1 0 decap_w0
xfeed_24585 1 0 decap_w0
xfeed_24584 1 0 decap_w0
xfeed_24583 1 0 decap_w0
xfeed_24582 1 0 decap_w0
xfeed_24581 1 0 decap_w0
xfeed_24580 1 0 decap_w0
xfeed_20279 1 0 decap_w0
xfeed_20278 1 0 decap_w0
xfeed_18589 1 0 decap_w0
xfeed_18588 1 0 decap_w0
xfeed_18587 1 0 decap_w0
xfeed_18586 1 0 decap_w0
xfeed_18585 1 0 decap_w0
xfeed_18584 1 0 decap_w0
xfeed_18583 1 0 decap_w0
xfeed_18582 1 0 decap_w0
xfeed_18581 1 0 decap_w0
xfeed_18580 1 0 decap_w0
xfeed_14279 1 0 decap_w0
xfeed_14278 1 0 decap_w0
xfeed_14277 1 0 decap_w0
xfeed_14276 1 0 decap_w0
xfeed_14275 1 0 decap_w0
xfeed_14274 1 0 decap_w0
xfeed_14273 1 0 decap_w0
xfeed_14272 1 0 decap_w0
xfeed_14271 1 0 decap_w0
xfeed_14270 1 0 decap_w0
xfeed_13749 1 0 decap_w0
xfeed_13748 1 0 decap_w0
xfeed_13747 1 0 decap_w0
xfeed_13746 1 0 decap_w0
xfeed_13745 1 0 decap_w0
xfeed_13744 1 0 decap_w0
xfeed_13743 1 0 decap_w0
xfeed_13742 1 0 decap_w0
xfeed_13741 1 0 decap_w0
xfeed_13740 1 0 decap_w0
xfeed_599 1 0 decap_w0
xfeed_598 1 0 decap_w0
xfeed_597 1 0 decap_w0
xfeed_596 1 0 decap_w0
xfeed_595 1 0 decap_w0
xfeed_594 1 0 decap_w0
xfeed_593 1 0 decap_w0
xfeed_592 1 0 decap_w0
xfeed_591 1 0 decap_w0
xfeed_31209 1 0 decap_w0
xfeed_31208 1 0 decap_w0
xfeed_31207 1 0 decap_w0
xfeed_31206 1 0 decap_w0
xfeed_31205 1 0 decap_w0
xfeed_31204 1 0 decap_w0
xfeed_31203 1 0 decap_w0
xfeed_31202 1 0 decap_w0
xfeed_31201 1 0 decap_w0
xfeed_31200 1 0 decap_w0
xfeed_30599 1 0 decap_w0
xfeed_30598 1 0 decap_w0
xfeed_30597 1 0 decap_w0
xfeed_30596 1 0 decap_w0
xfeed_30595 1 0 decap_w0
xfeed_30594 1 0 decap_w0
xfeed_30593 1 0 decap_w0
xfeed_30592 1 0 decap_w0
xfeed_30591 1 0 decap_w0
xfeed_30590 1 0 decap_w0
xfeed_29519 1 0 decap_w0
xfeed_29518 1 0 decap_w0
xfeed_29517 1 0 decap_w0
xfeed_29516 1 0 decap_w0
xfeed_29515 1 0 decap_w0
xfeed_29514 1 0 decap_w0
xfeed_29513 1 0 decap_w0
xfeed_29512 1 0 decap_w0
xfeed_29511 1 0 decap_w0
xfeed_29510 1 0 decap_w0
xfeed_25209 1 0 decap_w0
xfeed_25208 1 0 decap_w0
xfeed_25207 1 0 decap_w0
xfeed_25206 1 0 decap_w0
xfeed_25205 1 0 decap_w0
xfeed_25204 1 0 decap_w0
xfeed_25203 1 0 decap_w0
xfeed_25202 1 0 decap_w0
xfeed_25201 1 0 decap_w0
xfeed_25200 1 0 decap_w0
xfeed_20284 1 0 decap_w0
xfeed_20283 1 0 decap_w0
xfeed_20282 1 0 decap_w0
xfeed_20281 1 0 decap_w0
xfeed_20280 1 0 decap_w0
xfeed_8079 1 0 decap_w0
xfeed_8078 1 0 decap_w0
xfeed_8077 1 0 decap_w0
xfeed_8076 1 0 decap_w0
xfeed_8075 1 0 decap_w0
xfeed_8074 1 0 decap_w0
xfeed_8073 1 0 decap_w0
xfeed_8072 1 0 decap_w0
xfeed_8071 1 0 decap_w0
xfeed_8070 1 0 decap_w0
xfeed_7549 1 0 decap_w0
xfeed_7548 1 0 decap_w0
xfeed_7547 1 0 decap_w0
xfeed_7546 1 0 decap_w0
xfeed_7545 1 0 decap_w0
xfeed_7544 1 0 decap_w0
xfeed_7543 1 0 decap_w0
xfeed_7542 1 0 decap_w0
xfeed_7541 1 0 decap_w0
xfeed_7540 1 0 decap_w0
xfeed_3239 1 0 decap_w0
xfeed_3238 1 0 decap_w0
xfeed_3237 1 0 decap_w0
xfeed_3236 1 0 decap_w0
xfeed_3235 1 0 decap_w0
xfeed_3234 1 0 decap_w0
xfeed_3233 1 0 decap_w0
xfeed_3232 1 0 decap_w0
xfeed_3231 1 0 decap_w0
xfeed_3230 1 0 decap_w0
xfeed_2709 1 0 decap_w0
xfeed_2708 1 0 decap_w0
xfeed_2707 1 0 decap_w0
xfeed_2706 1 0 decap_w0
xfeed_2705 1 0 decap_w0
xfeed_2704 1 0 decap_w0
xfeed_2703 1 0 decap_w0
xfeed_2702 1 0 decap_w0
xfeed_2701 1 0 decap_w0
xfeed_2700 1 0 decap_w0
xfeed_24599 1 0 decap_w0
xfeed_24598 1 0 decap_w0
xfeed_24597 1 0 decap_w0
xfeed_24596 1 0 decap_w0
xfeed_24595 1 0 decap_w0
xfeed_24594 1 0 decap_w0
xfeed_24593 1 0 decap_w0
xfeed_24592 1 0 decap_w0
xfeed_24591 1 0 decap_w0
xfeed_24590 1 0 decap_w0
xfeed_20289 1 0 decap_w0
xfeed_20288 1 0 decap_w0
xfeed_20287 1 0 decap_w0
xfeed_20286 1 0 decap_w0
xfeed_20285 1 0 decap_w0
xfeed_19209 1 0 decap_w0
xfeed_19208 1 0 decap_w0
xfeed_19207 1 0 decap_w0
xfeed_19206 1 0 decap_w0
xfeed_19205 1 0 decap_w0
xfeed_19204 1 0 decap_w0
xfeed_19203 1 0 decap_w0
xfeed_19202 1 0 decap_w0
xfeed_19201 1 0 decap_w0
xfeed_19200 1 0 decap_w0
xfeed_18599 1 0 decap_w0
xfeed_18598 1 0 decap_w0
xfeed_18597 1 0 decap_w0
xfeed_18596 1 0 decap_w0
xfeed_18595 1 0 decap_w0
xfeed_18594 1 0 decap_w0
xfeed_18593 1 0 decap_w0
xfeed_18592 1 0 decap_w0
xfeed_18591 1 0 decap_w0
xfeed_18590 1 0 decap_w0
xfeed_14289 1 0 decap_w0
xfeed_14288 1 0 decap_w0
xfeed_14287 1 0 decap_w0
xfeed_14286 1 0 decap_w0
xfeed_14285 1 0 decap_w0
xfeed_14284 1 0 decap_w0
xfeed_14283 1 0 decap_w0
xfeed_14282 1 0 decap_w0
xfeed_14281 1 0 decap_w0
xfeed_14280 1 0 decap_w0
xfeed_13759 1 0 decap_w0
xfeed_13758 1 0 decap_w0
xfeed_13757 1 0 decap_w0
xfeed_13756 1 0 decap_w0
xfeed_13755 1 0 decap_w0
xfeed_13754 1 0 decap_w0
xfeed_13753 1 0 decap_w0
xfeed_13752 1 0 decap_w0
xfeed_13751 1 0 decap_w0
xfeed_13750 1 0 decap_w0
xfeed_31219 1 0 decap_w0
xfeed_31218 1 0 decap_w0
xfeed_31217 1 0 decap_w0
xfeed_31216 1 0 decap_w0
xfeed_31215 1 0 decap_w0
xfeed_31214 1 0 decap_w0
xfeed_31213 1 0 decap_w0
xfeed_31212 1 0 decap_w0
xfeed_31211 1 0 decap_w0
xfeed_31210 1 0 decap_w0
xfeed_29528 1 0 decap_w0
xfeed_29527 1 0 decap_w0
xfeed_29526 1 0 decap_w0
xfeed_29525 1 0 decap_w0
xfeed_29524 1 0 decap_w0
xfeed_29523 1 0 decap_w0
xfeed_29522 1 0 decap_w0
xfeed_29521 1 0 decap_w0
xfeed_29520 1 0 decap_w0
xfeed_25219 1 0 decap_w0
xfeed_25218 1 0 decap_w0
xfeed_25217 1 0 decap_w0
xfeed_25216 1 0 decap_w0
xfeed_25215 1 0 decap_w0
xfeed_25214 1 0 decap_w0
xfeed_25213 1 0 decap_w0
xfeed_25212 1 0 decap_w0
xfeed_25211 1 0 decap_w0
xfeed_25210 1 0 decap_w0
xfeed_20291 1 0 decap_w0
xfeed_20290 1 0 decap_w0
xfeed_8089 1 0 decap_w0
xfeed_8088 1 0 decap_w0
xfeed_8087 1 0 decap_w0
xfeed_8086 1 0 decap_w0
xfeed_8085 1 0 decap_w0
xfeed_8084 1 0 decap_w0
xfeed_8083 1 0 decap_w0
xfeed_8082 1 0 decap_w0
xfeed_8081 1 0 decap_w0
xfeed_8080 1 0 decap_w0
xfeed_7559 1 0 decap_w0
xfeed_7558 1 0 decap_w0
xfeed_7557 1 0 decap_w0
xfeed_7556 1 0 decap_w0
xfeed_7555 1 0 decap_w0
xfeed_7554 1 0 decap_w0
xfeed_7553 1 0 decap_w0
xfeed_7551 1 0 decap_w0
xfeed_7550 1 0 decap_w0
xfeed_3249 1 0 decap_w0
xfeed_3248 1 0 decap_w0
xfeed_3247 1 0 decap_w0
xfeed_3246 1 0 decap_w0
xfeed_3245 1 0 decap_w0
xfeed_3244 1 0 decap_w0
xfeed_3243 1 0 decap_w0
xfeed_3242 1 0 decap_w0
xfeed_3241 1 0 decap_w0
xfeed_3240 1 0 decap_w0
xfeed_2719 1 0 decap_w0
xfeed_2718 1 0 decap_w0
xfeed_2717 1 0 decap_w0
xfeed_2716 1 0 decap_w0
xfeed_2715 1 0 decap_w0
xfeed_2714 1 0 decap_w0
xfeed_2713 1 0 decap_w0
xfeed_2712 1 0 decap_w0
xfeed_2711 1 0 decap_w0
xfeed_2710 1 0 decap_w0
xfeed_29529 1 0 decap_w0
xfeed_20299 1 0 decap_w0
xfeed_20298 1 0 decap_w0
xfeed_20297 1 0 decap_w0
xfeed_20296 1 0 decap_w0
xfeed_20295 1 0 decap_w0
xfeed_20294 1 0 decap_w0
xfeed_20293 1 0 decap_w0
xfeed_20292 1 0 decap_w0
xfeed_19219 1 0 decap_w0
xfeed_19218 1 0 decap_w0
xfeed_19217 1 0 decap_w0
xfeed_19216 1 0 decap_w0
xfeed_19215 1 0 decap_w0
xfeed_19214 1 0 decap_w0
xfeed_19213 1 0 decap_w0
xfeed_19212 1 0 decap_w0
xfeed_19211 1 0 decap_w0
xfeed_19210 1 0 decap_w0
xfeed_14299 1 0 decap_w0
xfeed_14298 1 0 decap_w0
xfeed_14297 1 0 decap_w0
xfeed_14296 1 0 decap_w0
xfeed_14295 1 0 decap_w0
xfeed_14294 1 0 decap_w0
xfeed_14293 1 0 decap_w0
xfeed_14292 1 0 decap_w0
xfeed_14291 1 0 decap_w0
xfeed_14290 1 0 decap_w0
xfeed_13769 1 0 decap_w0
xfeed_13768 1 0 decap_w0
xfeed_13767 1 0 decap_w0
xfeed_13766 1 0 decap_w0
xfeed_13765 1 0 decap_w0
xfeed_13764 1 0 decap_w0
xfeed_13763 1 0 decap_w0
xfeed_13762 1 0 decap_w0
xfeed_13761 1 0 decap_w0
xfeed_13760 1 0 decap_w0
xfeed_31229 1 0 decap_w0
xfeed_31228 1 0 decap_w0
xfeed_31227 1 0 decap_w0
xfeed_31226 1 0 decap_w0
xfeed_31225 1 0 decap_w0
xfeed_31224 1 0 decap_w0
xfeed_31223 1 0 decap_w0
xfeed_31222 1 0 decap_w0
xfeed_31221 1 0 decap_w0
xfeed_31220 1 0 decap_w0
xfeed_29535 1 0 decap_w0
xfeed_29534 1 0 decap_w0
xfeed_29533 1 0 decap_w0
xfeed_29532 1 0 decap_w0
xfeed_29531 1 0 decap_w0
xfeed_29530 1 0 decap_w0
xfeed_25229 1 0 decap_w0
xfeed_25228 1 0 decap_w0
xfeed_25227 1 0 decap_w0
xfeed_25226 1 0 decap_w0
xfeed_25225 1 0 decap_w0
xfeed_25224 1 0 decap_w0
xfeed_25223 1 0 decap_w0
xfeed_25222 1 0 decap_w0
xfeed_25221 1 0 decap_w0
xfeed_25220 1 0 decap_w0
xfeed_8099 1 0 decap_w0
xfeed_8098 1 0 decap_w0
xfeed_8097 1 0 decap_w0
xfeed_8096 1 0 decap_w0
xfeed_8095 1 0 decap_w0
xfeed_8094 1 0 decap_w0
xfeed_8093 1 0 decap_w0
xfeed_8092 1 0 decap_w0
xfeed_8091 1 0 decap_w0
xfeed_8090 1 0 decap_w0
xfeed_7569 1 0 decap_w0
xfeed_7568 1 0 decap_w0
xfeed_7567 1 0 decap_w0
xfeed_7566 1 0 decap_w0
xfeed_7565 1 0 decap_w0
xfeed_7564 1 0 decap_w0
xfeed_7563 1 0 decap_w0
xfeed_7562 1 0 decap_w0
xfeed_7561 1 0 decap_w0
xfeed_7560 1 0 decap_w0
xfeed_3259 1 0 decap_w0
xfeed_3258 1 0 decap_w0
xfeed_3257 1 0 decap_w0
xfeed_3256 1 0 decap_w0
xfeed_3255 1 0 decap_w0
xfeed_3254 1 0 decap_w0
xfeed_3253 1 0 decap_w0
xfeed_3252 1 0 decap_w0
xfeed_3251 1 0 decap_w0
xfeed_3250 1 0 decap_w0
xfeed_2729 1 0 decap_w0
xfeed_2728 1 0 decap_w0
xfeed_2727 1 0 decap_w0
xfeed_2726 1 0 decap_w0
xfeed_2725 1 0 decap_w0
xfeed_2724 1 0 decap_w0
xfeed_2723 1 0 decap_w0
xfeed_2722 1 0 decap_w0
xfeed_2721 1 0 decap_w0
xfeed_2720 1 0 decap_w0
xfeed_709 1 0 decap_w0
xfeed_708 1 0 decap_w0
xfeed_707 1 0 decap_w0
xfeed_706 1 0 decap_w0
xfeed_705 1 0 decap_w0
xfeed_704 1 0 decap_w0
xfeed_703 1 0 decap_w0
xfeed_702 1 0 decap_w0
xfeed_701 1 0 decap_w0
xfeed_700 1 0 decap_w0
xfeed_29539 1 0 decap_w0
xfeed_29538 1 0 decap_w0
xfeed_29537 1 0 decap_w0
xfeed_29536 1 0 decap_w0
xfeed_19229 1 0 decap_w0
xfeed_19228 1 0 decap_w0
xfeed_19227 1 0 decap_w0
xfeed_19226 1 0 decap_w0
xfeed_19225 1 0 decap_w0
xfeed_19224 1 0 decap_w0
xfeed_19223 1 0 decap_w0
xfeed_19222 1 0 decap_w0
xfeed_19221 1 0 decap_w0
xfeed_19220 1 0 decap_w0
xfeed_13779 1 0 decap_w0
xfeed_13778 1 0 decap_w0
xfeed_13777 1 0 decap_w0
xfeed_13776 1 0 decap_w0
xfeed_13775 1 0 decap_w0
xfeed_13774 1 0 decap_w0
xfeed_13773 1 0 decap_w0
xfeed_13772 1 0 decap_w0
xfeed_13771 1 0 decap_w0
xfeed_13770 1 0 decap_w0
xfeed_31239 1 0 decap_w0
xfeed_31238 1 0 decap_w0
xfeed_31237 1 0 decap_w0
xfeed_31236 1 0 decap_w0
xfeed_31235 1 0 decap_w0
xfeed_31234 1 0 decap_w0
xfeed_31233 1 0 decap_w0
xfeed_31232 1 0 decap_w0
xfeed_31231 1 0 decap_w0
xfeed_31230 1 0 decap_w0
xfeed_30709 1 0 decap_w0
xfeed_30708 1 0 decap_w0
xfeed_30707 1 0 decap_w0
xfeed_30706 1 0 decap_w0
xfeed_30705 1 0 decap_w0
xfeed_30704 1 0 decap_w0
xfeed_30703 1 0 decap_w0
xfeed_30702 1 0 decap_w0
xfeed_30701 1 0 decap_w0
xfeed_30700 1 0 decap_w0
xfeed_29542 1 0 decap_w0
xfeed_29541 1 0 decap_w0
xfeed_29540 1 0 decap_w0
xfeed_25239 1 0 decap_w0
xfeed_25238 1 0 decap_w0
xfeed_25237 1 0 decap_w0
xfeed_25236 1 0 decap_w0
xfeed_25235 1 0 decap_w0
xfeed_25234 1 0 decap_w0
xfeed_25233 1 0 decap_w0
xfeed_25232 1 0 decap_w0
xfeed_25231 1 0 decap_w0
xfeed_25230 1 0 decap_w0
xfeed_24703 1 0 decap_w0
xfeed_24702 1 0 decap_w0
xfeed_24701 1 0 decap_w0
xfeed_24700 1 0 decap_w0
xfeed_7579 1 0 decap_w0
xfeed_7578 1 0 decap_w0
xfeed_7577 1 0 decap_w0
xfeed_7576 1 0 decap_w0
xfeed_7575 1 0 decap_w0
xfeed_7574 1 0 decap_w0
xfeed_7573 1 0 decap_w0
xfeed_7572 1 0 decap_w0
xfeed_7571 1 0 decap_w0
xfeed_7570 1 0 decap_w0
xfeed_3269 1 0 decap_w0
xfeed_3268 1 0 decap_w0
xfeed_3267 1 0 decap_w0
xfeed_3266 1 0 decap_w0
xfeed_3265 1 0 decap_w0
xfeed_3264 1 0 decap_w0
xfeed_3263 1 0 decap_w0
xfeed_3262 1 0 decap_w0
xfeed_3261 1 0 decap_w0
xfeed_3260 1 0 decap_w0
xfeed_2739 1 0 decap_w0
xfeed_2738 1 0 decap_w0
xfeed_2737 1 0 decap_w0
xfeed_2736 1 0 decap_w0
xfeed_2735 1 0 decap_w0
xfeed_2734 1 0 decap_w0
xfeed_2733 1 0 decap_w0
xfeed_2732 1 0 decap_w0
xfeed_2731 1 0 decap_w0
xfeed_2730 1 0 decap_w0
xfeed_716 1 0 decap_w0
xfeed_715 1 0 decap_w0
xfeed_714 1 0 decap_w0
xfeed_713 1 0 decap_w0
xfeed_712 1 0 decap_w0
xfeed_711 1 0 decap_w0
xfeed_710 1 0 decap_w0
xfeed_29549 1 0 decap_w0
xfeed_29548 1 0 decap_w0
xfeed_29547 1 0 decap_w0
xfeed_29546 1 0 decap_w0
xfeed_29545 1 0 decap_w0
xfeed_29544 1 0 decap_w0
xfeed_29543 1 0 decap_w0
xfeed_24709 1 0 decap_w0
xfeed_24708 1 0 decap_w0
xfeed_24707 1 0 decap_w0
xfeed_24706 1 0 decap_w0
xfeed_24705 1 0 decap_w0
xfeed_24704 1 0 decap_w0
xfeed_19239 1 0 decap_w0
xfeed_19238 1 0 decap_w0
xfeed_19237 1 0 decap_w0
xfeed_19236 1 0 decap_w0
xfeed_19235 1 0 decap_w0
xfeed_19234 1 0 decap_w0
xfeed_19233 1 0 decap_w0
xfeed_19232 1 0 decap_w0
xfeed_19231 1 0 decap_w0
xfeed_19230 1 0 decap_w0
xfeed_18709 1 0 decap_w0
xfeed_18708 1 0 decap_w0
xfeed_18707 1 0 decap_w0
xfeed_18706 1 0 decap_w0
xfeed_18705 1 0 decap_w0
xfeed_18704 1 0 decap_w0
xfeed_18703 1 0 decap_w0
xfeed_18702 1 0 decap_w0
xfeed_18701 1 0 decap_w0
xfeed_18700 1 0 decap_w0
xfeed_13789 1 0 decap_w0
xfeed_13788 1 0 decap_w0
xfeed_13787 1 0 decap_w0
xfeed_13786 1 0 decap_w0
xfeed_13785 1 0 decap_w0
xfeed_13784 1 0 decap_w0
xfeed_13783 1 0 decap_w0
xfeed_13782 1 0 decap_w0
xfeed_13781 1 0 decap_w0
xfeed_13780 1 0 decap_w0
xfeed_719 1 0 decap_w0
xfeed_718 1 0 decap_w0
xfeed_717 1 0 decap_w0
xfeed_31249 1 0 decap_w0
xfeed_31248 1 0 decap_w0
xfeed_31247 1 0 decap_w0
xfeed_31246 1 0 decap_w0
xfeed_31245 1 0 decap_w0
xfeed_31244 1 0 decap_w0
xfeed_31243 1 0 decap_w0
xfeed_31242 1 0 decap_w0
xfeed_31241 1 0 decap_w0
xfeed_31240 1 0 decap_w0
xfeed_30719 1 0 decap_w0
xfeed_30718 1 0 decap_w0
xfeed_30717 1 0 decap_w0
xfeed_30716 1 0 decap_w0
xfeed_30715 1 0 decap_w0
xfeed_30714 1 0 decap_w0
xfeed_30713 1 0 decap_w0
xfeed_30712 1 0 decap_w0
xfeed_30711 1 0 decap_w0
xfeed_30710 1 0 decap_w0
xfeed_25249 1 0 decap_w0
xfeed_25248 1 0 decap_w0
xfeed_25247 1 0 decap_w0
xfeed_25246 1 0 decap_w0
xfeed_25245 1 0 decap_w0
xfeed_25244 1 0 decap_w0
xfeed_25243 1 0 decap_w0
xfeed_25242 1 0 decap_w0
xfeed_25241 1 0 decap_w0
xfeed_25240 1 0 decap_w0
xfeed_24710 1 0 decap_w0
xfeed_20409 1 0 decap_w0
xfeed_20408 1 0 decap_w0
xfeed_20407 1 0 decap_w0
xfeed_20406 1 0 decap_w0
xfeed_20405 1 0 decap_w0
xfeed_20404 1 0 decap_w0
xfeed_20403 1 0 decap_w0
xfeed_20402 1 0 decap_w0
xfeed_20401 1 0 decap_w0
xfeed_20400 1 0 decap_w0
xfeed_7589 1 0 decap_w0
xfeed_7588 1 0 decap_w0
xfeed_7587 1 0 decap_w0
xfeed_7586 1 0 decap_w0
xfeed_7585 1 0 decap_w0
xfeed_7584 1 0 decap_w0
xfeed_7583 1 0 decap_w0
xfeed_7582 1 0 decap_w0
xfeed_7581 1 0 decap_w0
xfeed_7580 1 0 decap_w0
xfeed_3279 1 0 decap_w0
xfeed_3278 1 0 decap_w0
xfeed_3277 1 0 decap_w0
xfeed_3276 1 0 decap_w0
xfeed_3275 1 0 decap_w0
xfeed_3274 1 0 decap_w0
xfeed_3273 1 0 decap_w0
xfeed_3272 1 0 decap_w0
xfeed_3271 1 0 decap_w0
xfeed_3270 1 0 decap_w0
xfeed_2749 1 0 decap_w0
xfeed_2748 1 0 decap_w0
xfeed_2747 1 0 decap_w0
xfeed_2746 1 0 decap_w0
xfeed_2745 1 0 decap_w0
xfeed_2744 1 0 decap_w0
xfeed_2743 1 0 decap_w0
xfeed_2742 1 0 decap_w0
xfeed_2741 1 0 decap_w0
xfeed_2740 1 0 decap_w0
xfeed_723 1 0 decap_w0
xfeed_722 1 0 decap_w0
xfeed_721 1 0 decap_w0
xfeed_720 1 0 decap_w0
xsubckt_70_nexor2_x0 1 0 55 63 161 nexor2_x0
xfeed_29559 1 0 decap_w0
xfeed_29558 1 0 decap_w0
xfeed_29557 1 0 decap_w0
xfeed_29556 1 0 decap_w0
xfeed_29555 1 0 decap_w0
xfeed_29554 1 0 decap_w0
xfeed_29553 1 0 decap_w0
xfeed_29552 1 0 decap_w0
xfeed_29551 1 0 decap_w0
xfeed_29550 1 0 decap_w0
xfeed_24719 1 0 decap_w0
xfeed_24718 1 0 decap_w0
xfeed_24717 1 0 decap_w0
xfeed_24716 1 0 decap_w0
xfeed_24715 1 0 decap_w0
xfeed_24714 1 0 decap_w0
xfeed_24713 1 0 decap_w0
xfeed_24712 1 0 decap_w0
xfeed_24711 1 0 decap_w0
xfeed_19249 1 0 decap_w0
xfeed_19248 1 0 decap_w0
xfeed_19247 1 0 decap_w0
xfeed_19246 1 0 decap_w0
xfeed_19245 1 0 decap_w0
xfeed_19244 1 0 decap_w0
xfeed_19243 1 0 decap_w0
xfeed_19242 1 0 decap_w0
xfeed_19241 1 0 decap_w0
xfeed_19240 1 0 decap_w0
xfeed_18719 1 0 decap_w0
xfeed_18718 1 0 decap_w0
xfeed_18717 1 0 decap_w0
xfeed_18716 1 0 decap_w0
xfeed_18715 1 0 decap_w0
xfeed_18714 1 0 decap_w0
xfeed_18713 1 0 decap_w0
xfeed_18712 1 0 decap_w0
xfeed_18711 1 0 decap_w0
xfeed_18710 1 0 decap_w0
xfeed_14409 1 0 decap_w0
xfeed_14408 1 0 decap_w0
xfeed_14407 1 0 decap_w0
xfeed_14406 1 0 decap_w0
xfeed_14405 1 0 decap_w0
xfeed_14404 1 0 decap_w0
xfeed_14403 1 0 decap_w0
xfeed_14402 1 0 decap_w0
xfeed_14401 1 0 decap_w0
xfeed_14400 1 0 decap_w0
xfeed_13799 1 0 decap_w0
xfeed_13798 1 0 decap_w0
xfeed_13797 1 0 decap_w0
xfeed_13796 1 0 decap_w0
xfeed_13795 1 0 decap_w0
xfeed_13794 1 0 decap_w0
xfeed_13793 1 0 decap_w0
xfeed_13792 1 0 decap_w0
xfeed_13791 1 0 decap_w0
xfeed_13790 1 0 decap_w0
xfeed_8200 1 0 decap_w0
xfeed_729 1 0 decap_w0
xfeed_728 1 0 decap_w0
xfeed_727 1 0 decap_w0
xfeed_726 1 0 decap_w0
xfeed_725 1 0 decap_w0
xfeed_724 1 0 decap_w0
xsubckt_52_nexor2_x0 1 0 175 176 174 nexor2_x0
xfeed_31259 1 0 decap_w0
xfeed_31258 1 0 decap_w0
xfeed_31257 1 0 decap_w0
xfeed_31256 1 0 decap_w0
xfeed_31255 1 0 decap_w0
xfeed_31254 1 0 decap_w0
xfeed_31253 1 0 decap_w0
xfeed_31252 1 0 decap_w0
xfeed_31251 1 0 decap_w0
xfeed_31250 1 0 decap_w0
xfeed_30729 1 0 decap_w0
xfeed_30728 1 0 decap_w0
xfeed_30727 1 0 decap_w0
xfeed_30726 1 0 decap_w0
xfeed_30725 1 0 decap_w0
xfeed_30724 1 0 decap_w0
xfeed_30723 1 0 decap_w0
xfeed_30722 1 0 decap_w0
xfeed_30721 1 0 decap_w0
xfeed_30720 1 0 decap_w0
xfeed_25256 1 0 decap_w0
xfeed_25255 1 0 decap_w0
xfeed_25254 1 0 decap_w0
xfeed_25253 1 0 decap_w0
xfeed_25252 1 0 decap_w0
xfeed_25251 1 0 decap_w0
xfeed_25250 1 0 decap_w0
xfeed_20417 1 0 decap_w0
xfeed_20416 1 0 decap_w0
xfeed_20415 1 0 decap_w0
xfeed_20414 1 0 decap_w0
xfeed_20413 1 0 decap_w0
xfeed_20412 1 0 decap_w0
xfeed_20411 1 0 decap_w0
xfeed_20410 1 0 decap_w0
xfeed_8209 1 0 decap_w0
xfeed_8208 1 0 decap_w0
xfeed_8207 1 0 decap_w0
xfeed_8206 1 0 decap_w0
xfeed_8205 1 0 decap_w0
xfeed_8204 1 0 decap_w0
xfeed_8203 1 0 decap_w0
xfeed_8202 1 0 decap_w0
xfeed_8201 1 0 decap_w0
xfeed_7599 1 0 decap_w0
xfeed_7598 1 0 decap_w0
xfeed_7597 1 0 decap_w0
xfeed_7596 1 0 decap_w0
xfeed_7595 1 0 decap_w0
xfeed_7594 1 0 decap_w0
xfeed_7593 1 0 decap_w0
xfeed_7592 1 0 decap_w0
xfeed_7591 1 0 decap_w0
xfeed_7590 1 0 decap_w0
xfeed_3289 1 0 decap_w0
xfeed_3288 1 0 decap_w0
xfeed_3287 1 0 decap_w0
xfeed_3286 1 0 decap_w0
xfeed_3285 1 0 decap_w0
xfeed_3284 1 0 decap_w0
xfeed_3283 1 0 decap_w0
xfeed_3282 1 0 decap_w0
xfeed_3281 1 0 decap_w0
xfeed_3280 1 0 decap_w0
xfeed_2759 1 0 decap_w0
xfeed_2758 1 0 decap_w0
xfeed_2757 1 0 decap_w0
xfeed_2756 1 0 decap_w0
xfeed_2755 1 0 decap_w0
xfeed_2754 1 0 decap_w0
xfeed_2753 1 0 decap_w0
xfeed_2752 1 0 decap_w0
xfeed_2751 1 0 decap_w0
xfeed_2750 1 0 decap_w0
xfeed_730 1 0 decap_w0
xsubckt_43_nexor2_x0 1 0 180 183 179 nexor2_x0
xsubckt_34_nexor2_x0 1 0 49 36 116 nexor2_x0
xfeed_29569 1 0 decap_w0
xfeed_29568 1 0 decap_w0
xfeed_29567 1 0 decap_w0
xfeed_29566 1 0 decap_w0
xfeed_29565 1 0 decap_w0
xfeed_29564 1 0 decap_w0
xfeed_29563 1 0 decap_w0
xfeed_29562 1 0 decap_w0
xfeed_29561 1 0 decap_w0
xfeed_29560 1 0 decap_w0
xfeed_25259 1 0 decap_w0
xfeed_25258 1 0 decap_w0
xfeed_25257 1 0 decap_w0
xfeed_24729 1 0 decap_w0
xfeed_24728 1 0 decap_w0
xfeed_24727 1 0 decap_w0
xfeed_24726 1 0 decap_w0
xfeed_24725 1 0 decap_w0
xfeed_24724 1 0 decap_w0
xfeed_24723 1 0 decap_w0
xfeed_24722 1 0 decap_w0
xfeed_24721 1 0 decap_w0
xfeed_24720 1 0 decap_w0
xfeed_20419 1 0 decap_w0
xfeed_20418 1 0 decap_w0
xfeed_19259 1 0 decap_w0
xfeed_19258 1 0 decap_w0
xfeed_19257 1 0 decap_w0
xfeed_19256 1 0 decap_w0
xfeed_19255 1 0 decap_w0
xfeed_19254 1 0 decap_w0
xfeed_19253 1 0 decap_w0
xfeed_19252 1 0 decap_w0
xfeed_19251 1 0 decap_w0
xfeed_19250 1 0 decap_w0
xfeed_18729 1 0 decap_w0
xfeed_18728 1 0 decap_w0
xfeed_18727 1 0 decap_w0
xfeed_18726 1 0 decap_w0
xfeed_18725 1 0 decap_w0
xfeed_18724 1 0 decap_w0
xfeed_18723 1 0 decap_w0
xfeed_18722 1 0 decap_w0
xfeed_18721 1 0 decap_w0
xfeed_18720 1 0 decap_w0
xfeed_14419 1 0 decap_w0
xfeed_14418 1 0 decap_w0
xfeed_14417 1 0 decap_w0
xfeed_14416 1 0 decap_w0
xfeed_14415 1 0 decap_w0
xfeed_14414 1 0 decap_w0
xfeed_14413 1 0 decap_w0
xfeed_14412 1 0 decap_w0
xfeed_14411 1 0 decap_w0
xfeed_14410 1 0 decap_w0
xfeed_10109 1 0 decap_w0
xfeed_10108 1 0 decap_w0
xfeed_10107 1 0 decap_w0
xfeed_10106 1 0 decap_w0
xfeed_10105 1 0 decap_w0
xfeed_10104 1 0 decap_w0
xfeed_10103 1 0 decap_w0
xfeed_10102 1 0 decap_w0
xfeed_10101 1 0 decap_w0
xfeed_10100 1 0 decap_w0
xfeed_739 1 0 decap_w0
xfeed_738 1 0 decap_w0
xfeed_737 1 0 decap_w0
xfeed_736 1 0 decap_w0
xfeed_735 1 0 decap_w0
xfeed_734 1 0 decap_w0
xfeed_733 1 0 decap_w0
xfeed_732 1 0 decap_w0
xfeed_731 1 0 decap_w0
xfeed_31269 1 0 decap_w0
xfeed_31268 1 0 decap_w0
xfeed_31267 1 0 decap_w0
xfeed_31266 1 0 decap_w0
xfeed_31265 1 0 decap_w0
xfeed_31264 1 0 decap_w0
xfeed_31263 1 0 decap_w0
xfeed_31262 1 0 decap_w0
xfeed_31261 1 0 decap_w0
xfeed_31260 1 0 decap_w0
xfeed_30739 1 0 decap_w0
xfeed_30738 1 0 decap_w0
xfeed_30737 1 0 decap_w0
xfeed_30736 1 0 decap_w0
xfeed_30735 1 0 decap_w0
xfeed_30734 1 0 decap_w0
xfeed_30733 1 0 decap_w0
xfeed_30732 1 0 decap_w0
xfeed_30731 1 0 decap_w0
xfeed_30730 1 0 decap_w0
xfeed_25263 1 0 decap_w0
xfeed_25262 1 0 decap_w0
xfeed_25261 1 0 decap_w0
xfeed_25260 1 0 decap_w0
xfeed_20424 1 0 decap_w0
xfeed_20423 1 0 decap_w0
xfeed_20422 1 0 decap_w0
xfeed_20421 1 0 decap_w0
xfeed_20420 1 0 decap_w0
xfeed_8219 1 0 decap_w0
xfeed_8218 1 0 decap_w0
xfeed_8217 1 0 decap_w0
xfeed_8216 1 0 decap_w0
xfeed_8215 1 0 decap_w0
xfeed_8214 1 0 decap_w0
xfeed_8213 1 0 decap_w0
xfeed_8212 1 0 decap_w0
xfeed_8211 1 0 decap_w0
xfeed_8210 1 0 decap_w0
xfeed_3299 1 0 decap_w0
xfeed_3298 1 0 decap_w0
xfeed_3297 1 0 decap_w0
xfeed_3296 1 0 decap_w0
xfeed_3295 1 0 decap_w0
xfeed_3294 1 0 decap_w0
xfeed_3293 1 0 decap_w0
xfeed_3292 1 0 decap_w0
xfeed_3291 1 0 decap_w0
xfeed_3290 1 0 decap_w0
xfeed_2769 1 0 decap_w0
xfeed_2768 1 0 decap_w0
xfeed_2767 1 0 decap_w0
xfeed_2766 1 0 decap_w0
xfeed_2765 1 0 decap_w0
xfeed_2764 1 0 decap_w0
xfeed_2763 1 0 decap_w0
xfeed_2762 1 0 decap_w0
xfeed_2761 1 0 decap_w0
xfeed_2760 1 0 decap_w0
xsubckt_16_nexor2_x0 1 0 129 16 12 nexor2_x0
xfeed_29579 1 0 decap_w0
xfeed_29578 1 0 decap_w0
xfeed_29577 1 0 decap_w0
xfeed_29576 1 0 decap_w0
xfeed_29575 1 0 decap_w0
xfeed_29574 1 0 decap_w0
xfeed_29573 1 0 decap_w0
xfeed_29572 1 0 decap_w0
xfeed_29571 1 0 decap_w0
xfeed_29570 1 0 decap_w0
xfeed_25269 1 0 decap_w0
xfeed_25268 1 0 decap_w0
xfeed_25267 1 0 decap_w0
xfeed_25266 1 0 decap_w0
xfeed_25265 1 0 decap_w0
xfeed_25264 1 0 decap_w0
xfeed_24739 1 0 decap_w0
xfeed_24738 1 0 decap_w0
xfeed_24737 1 0 decap_w0
xfeed_24736 1 0 decap_w0
xfeed_24735 1 0 decap_w0
xfeed_24734 1 0 decap_w0
xfeed_24733 1 0 decap_w0
xfeed_24732 1 0 decap_w0
xfeed_24731 1 0 decap_w0
xfeed_24730 1 0 decap_w0
xfeed_20429 1 0 decap_w0
xfeed_20428 1 0 decap_w0
xfeed_20427 1 0 decap_w0
xfeed_20426 1 0 decap_w0
xfeed_20425 1 0 decap_w0
xfeed_19269 1 0 decap_w0
xfeed_19268 1 0 decap_w0
xfeed_19267 1 0 decap_w0
xfeed_19266 1 0 decap_w0
xfeed_19265 1 0 decap_w0
xfeed_19264 1 0 decap_w0
xfeed_19263 1 0 decap_w0
xfeed_19262 1 0 decap_w0
xfeed_19261 1 0 decap_w0
xfeed_19260 1 0 decap_w0
xfeed_18739 1 0 decap_w0
xfeed_18738 1 0 decap_w0
xfeed_18737 1 0 decap_w0
xfeed_18736 1 0 decap_w0
xfeed_18735 1 0 decap_w0
xfeed_18734 1 0 decap_w0
xfeed_18733 1 0 decap_w0
xfeed_18732 1 0 decap_w0
xfeed_18731 1 0 decap_w0
xfeed_18730 1 0 decap_w0
xfeed_14429 1 0 decap_w0
xfeed_14428 1 0 decap_w0
xfeed_14427 1 0 decap_w0
xfeed_14426 1 0 decap_w0
xfeed_14425 1 0 decap_w0
xfeed_14424 1 0 decap_w0
xfeed_14423 1 0 decap_w0
xfeed_14422 1 0 decap_w0
xfeed_14421 1 0 decap_w0
xfeed_14420 1 0 decap_w0
xfeed_10119 1 0 decap_w0
xfeed_10118 1 0 decap_w0
xfeed_10117 1 0 decap_w0
xfeed_10116 1 0 decap_w0
xfeed_10115 1 0 decap_w0
xfeed_10114 1 0 decap_w0
xfeed_10113 1 0 decap_w0
xfeed_10112 1 0 decap_w0
xfeed_10111 1 0 decap_w0
xfeed_10110 1 0 decap_w0
xfeed_749 1 0 decap_w0
xfeed_748 1 0 decap_w0
xfeed_747 1 0 decap_w0
xfeed_746 1 0 decap_w0
xfeed_745 1 0 decap_w0
xfeed_744 1 0 decap_w0
xfeed_743 1 0 decap_w0
xfeed_742 1 0 decap_w0
xfeed_741 1 0 decap_w0
xfeed_740 1 0 decap_w0
xfeed_31279 1 0 decap_w0
xfeed_31278 1 0 decap_w0
xfeed_31277 1 0 decap_w0
xfeed_31276 1 0 decap_w0
xfeed_31275 1 0 decap_w0
xfeed_31274 1 0 decap_w0
xfeed_31273 1 0 decap_w0
xfeed_31272 1 0 decap_w0
xfeed_31271 1 0 decap_w0
xfeed_31270 1 0 decap_w0
xfeed_30749 1 0 decap_w0
xfeed_30748 1 0 decap_w0
xfeed_30747 1 0 decap_w0
xfeed_30746 1 0 decap_w0
xfeed_30745 1 0 decap_w0
xfeed_30744 1 0 decap_w0
xfeed_30743 1 0 decap_w0
xfeed_30742 1 0 decap_w0
xfeed_30741 1 0 decap_w0
xfeed_30740 1 0 decap_w0
xfeed_25270 1 0 decap_w0
xfeed_20431 1 0 decap_w0
xfeed_20430 1 0 decap_w0
xfeed_8229 1 0 decap_w0
xfeed_8228 1 0 decap_w0
xfeed_8227 1 0 decap_w0
xfeed_8226 1 0 decap_w0
xfeed_8225 1 0 decap_w0
xfeed_8224 1 0 decap_w0
xfeed_8223 1 0 decap_w0
xfeed_8222 1 0 decap_w0
xfeed_8221 1 0 decap_w0
xfeed_8220 1 0 decap_w0
xfeed_2779 1 0 decap_w0
xfeed_2778 1 0 decap_w0
xfeed_2777 1 0 decap_w0
xfeed_2776 1 0 decap_w0
xfeed_2775 1 0 decap_w0
xfeed_2774 1 0 decap_w0
xfeed_2773 1 0 decap_w0
xfeed_2772 1 0 decap_w0
xfeed_2771 1 0 decap_w0
xfeed_2770 1 0 decap_w0
xsubckt_94_nexor2_x0 1 0 144 150 143 nexor2_x0
xfeed_29589 1 0 decap_w0
xfeed_29588 1 0 decap_w0
xfeed_29587 1 0 decap_w0
xfeed_29586 1 0 decap_w0
xfeed_29585 1 0 decap_w0
xfeed_29584 1 0 decap_w0
xfeed_29583 1 0 decap_w0
xfeed_29582 1 0 decap_w0
xfeed_29581 1 0 decap_w0
xfeed_29580 1 0 decap_w0
xfeed_25279 1 0 decap_w0
xfeed_25278 1 0 decap_w0
xfeed_25277 1 0 decap_w0
xfeed_25276 1 0 decap_w0
xfeed_25275 1 0 decap_w0
xfeed_25274 1 0 decap_w0
xfeed_25273 1 0 decap_w0
xfeed_25272 1 0 decap_w0
xfeed_25271 1 0 decap_w0
xfeed_24749 1 0 decap_w0
xfeed_24748 1 0 decap_w0
xfeed_24747 1 0 decap_w0
xfeed_24746 1 0 decap_w0
xfeed_24745 1 0 decap_w0
xfeed_24744 1 0 decap_w0
xfeed_24743 1 0 decap_w0
xfeed_24742 1 0 decap_w0
xfeed_24741 1 0 decap_w0
xfeed_24740 1 0 decap_w0
xfeed_20439 1 0 decap_w0
xfeed_20438 1 0 decap_w0
xfeed_20437 1 0 decap_w0
xfeed_20436 1 0 decap_w0
xfeed_20435 1 0 decap_w0
xfeed_20434 1 0 decap_w0
xfeed_20433 1 0 decap_w0
xfeed_20432 1 0 decap_w0
xfeed_19279 1 0 decap_w0
xfeed_19278 1 0 decap_w0
xfeed_19277 1 0 decap_w0
xfeed_19276 1 0 decap_w0
xfeed_19275 1 0 decap_w0
xfeed_19274 1 0 decap_w0
xfeed_19273 1 0 decap_w0
xfeed_19272 1 0 decap_w0
xfeed_19271 1 0 decap_w0
xfeed_19270 1 0 decap_w0
xfeed_18749 1 0 decap_w0
xfeed_18748 1 0 decap_w0
xfeed_18747 1 0 decap_w0
xfeed_18746 1 0 decap_w0
xfeed_18745 1 0 decap_w0
xfeed_18744 1 0 decap_w0
xfeed_18743 1 0 decap_w0
xfeed_18742 1 0 decap_w0
xfeed_18741 1 0 decap_w0
xfeed_18740 1 0 decap_w0
xfeed_14439 1 0 decap_w0
xfeed_14438 1 0 decap_w0
xfeed_14437 1 0 decap_w0
xfeed_14436 1 0 decap_w0
xfeed_14435 1 0 decap_w0
xfeed_14434 1 0 decap_w0
xfeed_14433 1 0 decap_w0
xfeed_14432 1 0 decap_w0
xfeed_14431 1 0 decap_w0
xfeed_14430 1 0 decap_w0
xfeed_13909 1 0 decap_w0
xfeed_13908 1 0 decap_w0
xfeed_13907 1 0 decap_w0
xfeed_13906 1 0 decap_w0
xfeed_13905 1 0 decap_w0
xfeed_13904 1 0 decap_w0
xfeed_13903 1 0 decap_w0
xfeed_13902 1 0 decap_w0
xfeed_13901 1 0 decap_w0
xfeed_13900 1 0 decap_w0
xfeed_10129 1 0 decap_w0
xfeed_10128 1 0 decap_w0
xfeed_10127 1 0 decap_w0
xfeed_10126 1 0 decap_w0
xfeed_10125 1 0 decap_w0
xfeed_10124 1 0 decap_w0
xfeed_10123 1 0 decap_w0
xfeed_10122 1 0 decap_w0
xfeed_10121 1 0 decap_w0
xfeed_10120 1 0 decap_w0
xfeed_759 1 0 decap_w0
xfeed_758 1 0 decap_w0
xfeed_757 1 0 decap_w0
xfeed_756 1 0 decap_w0
xfeed_755 1 0 decap_w0
xfeed_754 1 0 decap_w0
xfeed_753 1 0 decap_w0
xfeed_752 1 0 decap_w0
xfeed_751 1 0 decap_w0
xfeed_750 1 0 decap_w0
xsubckt_76_nexor2_x0 1 0 50 37 157 nexor2_x0
xsubckt_85_nexor2_x0 1 0 151 172 150 nexor2_x0
xfeed_31289 1 0 decap_w0
xfeed_31288 1 0 decap_w0
xfeed_31287 1 0 decap_w0
xfeed_31286 1 0 decap_w0
xfeed_31285 1 0 decap_w0
xfeed_31284 1 0 decap_w0
xfeed_31283 1 0 decap_w0
xfeed_31282 1 0 decap_w0
xfeed_31281 1 0 decap_w0
xfeed_31280 1 0 decap_w0
xfeed_30759 1 0 decap_w0
xfeed_30758 1 0 decap_w0
xfeed_30757 1 0 decap_w0
xfeed_30756 1 0 decap_w0
xfeed_30755 1 0 decap_w0
xfeed_30754 1 0 decap_w0
xfeed_30753 1 0 decap_w0
xfeed_30752 1 0 decap_w0
xfeed_30751 1 0 decap_w0
xfeed_30750 1 0 decap_w0
xfeed_8239 1 0 decap_w0
xfeed_8238 1 0 decap_w0
xfeed_8237 1 0 decap_w0
xfeed_8236 1 0 decap_w0
xfeed_8235 1 0 decap_w0
xfeed_8234 1 0 decap_w0
xfeed_8233 1 0 decap_w0
xfeed_8232 1 0 decap_w0
xfeed_8231 1 0 decap_w0
xfeed_8230 1 0 decap_w0
xfeed_7709 1 0 decap_w0
xfeed_7708 1 0 decap_w0
xfeed_7707 1 0 decap_w0
xfeed_7706 1 0 decap_w0
xfeed_7705 1 0 decap_w0
xfeed_7704 1 0 decap_w0
xfeed_7703 1 0 decap_w0
xfeed_7702 1 0 decap_w0
xfeed_7701 1 0 decap_w0
xfeed_7700 1 0 decap_w0
xfeed_2789 1 0 decap_w0
xfeed_2788 1 0 decap_w0
xfeed_2787 1 0 decap_w0
xfeed_2786 1 0 decap_w0
xfeed_2785 1 0 decap_w0
xfeed_2784 1 0 decap_w0
xfeed_2783 1 0 decap_w0
xfeed_2782 1 0 decap_w0
xfeed_2781 1 0 decap_w0
xfeed_2780 1 0 decap_w0
xsubckt_67_nexor2_x0 1 0 165 171 163 nexor2_x0
xfeed_29599 1 0 decap_w0
xfeed_29598 1 0 decap_w0
xfeed_29597 1 0 decap_w0
xfeed_29596 1 0 decap_w0
xfeed_29595 1 0 decap_w0
xfeed_29594 1 0 decap_w0
xfeed_29593 1 0 decap_w0
xfeed_29592 1 0 decap_w0
xfeed_29591 1 0 decap_w0
xfeed_29590 1 0 decap_w0
xfeed_25289 1 0 decap_w0
xfeed_25288 1 0 decap_w0
xfeed_25287 1 0 decap_w0
xfeed_25286 1 0 decap_w0
xfeed_25285 1 0 decap_w0
xfeed_25284 1 0 decap_w0
xfeed_25283 1 0 decap_w0
xfeed_25282 1 0 decap_w0
xfeed_25281 1 0 decap_w0
xfeed_25280 1 0 decap_w0
xfeed_24759 1 0 decap_w0
xfeed_24758 1 0 decap_w0
xfeed_24757 1 0 decap_w0
xfeed_24756 1 0 decap_w0
xfeed_24755 1 0 decap_w0
xfeed_24754 1 0 decap_w0
xfeed_24753 1 0 decap_w0
xfeed_24752 1 0 decap_w0
xfeed_24751 1 0 decap_w0
xfeed_24750 1 0 decap_w0
xfeed_20449 1 0 decap_w0
xfeed_20448 1 0 decap_w0
xfeed_20447 1 0 decap_w0
xfeed_20446 1 0 decap_w0
xfeed_20445 1 0 decap_w0
xfeed_20444 1 0 decap_w0
xfeed_20443 1 0 decap_w0
xfeed_20442 1 0 decap_w0
xfeed_20441 1 0 decap_w0
xfeed_20440 1 0 decap_w0
xfeed_19289 1 0 decap_w0
xfeed_19288 1 0 decap_w0
xfeed_19287 1 0 decap_w0
xfeed_19286 1 0 decap_w0
xfeed_19285 1 0 decap_w0
xfeed_19284 1 0 decap_w0
xfeed_19283 1 0 decap_w0
xfeed_19282 1 0 decap_w0
xfeed_19281 1 0 decap_w0
xfeed_19280 1 0 decap_w0
xfeed_18759 1 0 decap_w0
xfeed_18758 1 0 decap_w0
xfeed_18757 1 0 decap_w0
xfeed_18756 1 0 decap_w0
xfeed_18755 1 0 decap_w0
xfeed_18754 1 0 decap_w0
xfeed_18753 1 0 decap_w0
xfeed_18752 1 0 decap_w0
xfeed_18751 1 0 decap_w0
xfeed_18750 1 0 decap_w0
xfeed_14449 1 0 decap_w0
xfeed_14448 1 0 decap_w0
xfeed_14447 1 0 decap_w0
xfeed_14446 1 0 decap_w0
xfeed_14445 1 0 decap_w0
xfeed_14444 1 0 decap_w0
xfeed_14443 1 0 decap_w0
xfeed_14442 1 0 decap_w0
xfeed_14441 1 0 decap_w0
xfeed_14440 1 0 decap_w0
xfeed_13919 1 0 decap_w0
xfeed_13918 1 0 decap_w0
xfeed_13917 1 0 decap_w0
xfeed_13916 1 0 decap_w0
xfeed_13915 1 0 decap_w0
xfeed_13914 1 0 decap_w0
xfeed_13913 1 0 decap_w0
xfeed_13912 1 0 decap_w0
xfeed_13911 1 0 decap_w0
xfeed_13910 1 0 decap_w0
xfeed_10139 1 0 decap_w0
xfeed_10138 1 0 decap_w0
xfeed_10137 1 0 decap_w0
xfeed_10136 1 0 decap_w0
xfeed_10135 1 0 decap_w0
xfeed_10134 1 0 decap_w0
xfeed_10133 1 0 decap_w0
xfeed_10132 1 0 decap_w0
xfeed_10131 1 0 decap_w0
xfeed_10130 1 0 decap_w0
xfeed_769 1 0 decap_w0
xfeed_768 1 0 decap_w0
xfeed_767 1 0 decap_w0
xfeed_766 1 0 decap_w0
xfeed_765 1 0 decap_w0
xfeed_764 1 0 decap_w0
xfeed_763 1 0 decap_w0
xfeed_762 1 0 decap_w0
xfeed_761 1 0 decap_w0
xfeed_760 1 0 decap_w0
xfeed_31299 1 0 decap_w0
xfeed_31298 1 0 decap_w0
xfeed_31297 1 0 decap_w0
xfeed_31296 1 0 decap_w0
xfeed_31295 1 0 decap_w0
xfeed_31294 1 0 decap_w0
xfeed_31293 1 0 decap_w0
xfeed_31292 1 0 decap_w0
xfeed_31291 1 0 decap_w0
xfeed_31290 1 0 decap_w0
xfeed_30769 1 0 decap_w0
xfeed_30768 1 0 decap_w0
xfeed_30767 1 0 decap_w0
xfeed_30766 1 0 decap_w0
xfeed_30765 1 0 decap_w0
xfeed_30764 1 0 decap_w0
xfeed_30763 1 0 decap_w0
xfeed_30762 1 0 decap_w0
xfeed_30761 1 0 decap_w0
xfeed_30760 1 0 decap_w0
xfeed_8249 1 0 decap_w0
xfeed_8248 1 0 decap_w0
xfeed_8247 1 0 decap_w0
xfeed_8246 1 0 decap_w0
xfeed_8245 1 0 decap_w0
xfeed_8244 1 0 decap_w0
xfeed_8243 1 0 decap_w0
xfeed_8242 1 0 decap_w0
xfeed_8241 1 0 decap_w0
xfeed_8240 1 0 decap_w0
xfeed_7719 1 0 decap_w0
xfeed_7718 1 0 decap_w0
xfeed_7717 1 0 decap_w0
xfeed_7716 1 0 decap_w0
xfeed_7715 1 0 decap_w0
xfeed_7714 1 0 decap_w0
xfeed_7713 1 0 decap_w0
xfeed_7712 1 0 decap_w0
xfeed_7711 1 0 decap_w0
xfeed_7710 1 0 decap_w0
xfeed_3409 1 0 decap_w0
xfeed_3408 1 0 decap_w0
xfeed_3407 1 0 decap_w0
xfeed_3406 1 0 decap_w0
xfeed_3405 1 0 decap_w0
xfeed_3404 1 0 decap_w0
xfeed_3403 1 0 decap_w0
xfeed_3402 1 0 decap_w0
xfeed_3401 1 0 decap_w0
xfeed_3400 1 0 decap_w0
xfeed_2799 1 0 decap_w0
xfeed_2798 1 0 decap_w0
xfeed_2797 1 0 decap_w0
xfeed_2796 1 0 decap_w0
xfeed_2795 1 0 decap_w0
xfeed_2794 1 0 decap_w0
xfeed_2793 1 0 decap_w0
xfeed_2792 1 0 decap_w0
xfeed_2791 1 0 decap_w0
xfeed_2790 1 0 decap_w0
xsubckt_49_nexor2_x0 1 0 37 63 176 nexor2_x0
xfeed_25299 1 0 decap_w0
xfeed_25298 1 0 decap_w0
xfeed_25297 1 0 decap_w0
xfeed_25296 1 0 decap_w0
xfeed_25295 1 0 decap_w0
xfeed_25294 1 0 decap_w0
xfeed_25293 1 0 decap_w0
xfeed_25292 1 0 decap_w0
xfeed_25291 1 0 decap_w0
xfeed_25290 1 0 decap_w0
xfeed_24769 1 0 decap_w0
xfeed_24768 1 0 decap_w0
xfeed_24767 1 0 decap_w0
xfeed_24766 1 0 decap_w0
xfeed_24765 1 0 decap_w0
xfeed_24764 1 0 decap_w0
xfeed_24763 1 0 decap_w0
xfeed_24762 1 0 decap_w0
xfeed_24761 1 0 decap_w0
xfeed_24760 1 0 decap_w0
xfeed_20459 1 0 decap_w0
xfeed_20458 1 0 decap_w0
xfeed_20457 1 0 decap_w0
xfeed_20456 1 0 decap_w0
xfeed_20455 1 0 decap_w0
xfeed_20454 1 0 decap_w0
xfeed_20453 1 0 decap_w0
xfeed_20452 1 0 decap_w0
xfeed_20451 1 0 decap_w0
xfeed_20450 1 0 decap_w0
xfeed_19299 1 0 decap_w0
xfeed_19298 1 0 decap_w0
xfeed_19297 1 0 decap_w0
xfeed_19296 1 0 decap_w0
xfeed_19295 1 0 decap_w0
xfeed_19294 1 0 decap_w0
xfeed_19293 1 0 decap_w0
xfeed_19292 1 0 decap_w0
xfeed_19291 1 0 decap_w0
xfeed_19290 1 0 decap_w0
xfeed_18769 1 0 decap_w0
xfeed_18768 1 0 decap_w0
xfeed_18767 1 0 decap_w0
xfeed_18766 1 0 decap_w0
xfeed_18765 1 0 decap_w0
xfeed_18764 1 0 decap_w0
xfeed_18763 1 0 decap_w0
xfeed_18762 1 0 decap_w0
xfeed_18761 1 0 decap_w0
xfeed_18760 1 0 decap_w0
xfeed_14459 1 0 decap_w0
xfeed_14458 1 0 decap_w0
xfeed_14457 1 0 decap_w0
xfeed_14456 1 0 decap_w0
xfeed_14455 1 0 decap_w0
xfeed_14454 1 0 decap_w0
xfeed_14453 1 0 decap_w0
xfeed_14452 1 0 decap_w0
xfeed_14451 1 0 decap_w0
xfeed_14450 1 0 decap_w0
xfeed_13929 1 0 decap_w0
xfeed_13928 1 0 decap_w0
xfeed_13927 1 0 decap_w0
xfeed_13926 1 0 decap_w0
xfeed_13925 1 0 decap_w0
xfeed_13924 1 0 decap_w0
xfeed_13923 1 0 decap_w0
xfeed_13922 1 0 decap_w0
xfeed_13921 1 0 decap_w0
xfeed_13920 1 0 decap_w0
xfeed_10149 1 0 decap_w0
xfeed_10148 1 0 decap_w0
xfeed_10147 1 0 decap_w0
xfeed_10146 1 0 decap_w0
xfeed_10145 1 0 decap_w0
xfeed_10144 1 0 decap_w0
xfeed_10143 1 0 decap_w0
xfeed_10142 1 0 decap_w0
xfeed_10141 1 0 decap_w0
xfeed_10140 1 0 decap_w0
xfeed_779 1 0 decap_w0
xfeed_778 1 0 decap_w0
xfeed_777 1 0 decap_w0
xfeed_776 1 0 decap_w0
xfeed_775 1 0 decap_w0
xfeed_774 1 0 decap_w0
xfeed_773 1 0 decap_w0
xfeed_772 1 0 decap_w0
xfeed_771 1 0 decap_w0
xfeed_770 1 0 decap_w0
xfeed_30779 1 0 decap_w0
xfeed_30778 1 0 decap_w0
xfeed_30777 1 0 decap_w0
xfeed_30776 1 0 decap_w0
xfeed_30775 1 0 decap_w0
xfeed_30774 1 0 decap_w0
xfeed_30773 1 0 decap_w0
xfeed_30772 1 0 decap_w0
xfeed_30771 1 0 decap_w0
xfeed_30770 1 0 decap_w0
xfeed_8259 1 0 decap_w0
xfeed_8258 1 0 decap_w0
xfeed_8257 1 0 decap_w0
xfeed_8256 1 0 decap_w0
xfeed_8255 1 0 decap_w0
xfeed_8254 1 0 decap_w0
xfeed_8253 1 0 decap_w0
xfeed_8252 1 0 decap_w0
xfeed_8251 1 0 decap_w0
xfeed_8250 1 0 decap_w0
xfeed_7729 1 0 decap_w0
xfeed_7728 1 0 decap_w0
xfeed_7727 1 0 decap_w0
xfeed_7726 1 0 decap_w0
xfeed_7725 1 0 decap_w0
xfeed_7724 1 0 decap_w0
xfeed_7723 1 0 decap_w0
xfeed_7722 1 0 decap_w0
xfeed_7721 1 0 decap_w0
xfeed_7720 1 0 decap_w0
xfeed_3419 1 0 decap_w0
xfeed_3418 1 0 decap_w0
xfeed_3417 1 0 decap_w0
xfeed_3416 1 0 decap_w0
xfeed_3415 1 0 decap_w0
xfeed_3414 1 0 decap_w0
xfeed_3413 1 0 decap_w0
xfeed_3412 1 0 decap_w0
xfeed_3411 1 0 decap_w0
xfeed_3410 1 0 decap_w0
xfeed_24779 1 0 decap_w0
xfeed_24778 1 0 decap_w0
xfeed_24777 1 0 decap_w0
xfeed_24776 1 0 decap_w0
xfeed_24775 1 0 decap_w0
xfeed_24774 1 0 decap_w0
xfeed_24773 1 0 decap_w0
xfeed_24772 1 0 decap_w0
xfeed_24771 1 0 decap_w0
xfeed_24770 1 0 decap_w0
xfeed_20469 1 0 decap_w0
xfeed_20468 1 0 decap_w0
xfeed_20467 1 0 decap_w0
xfeed_20466 1 0 decap_w0
xfeed_20465 1 0 decap_w0
xfeed_20464 1 0 decap_w0
xfeed_20463 1 0 decap_w0
xfeed_20462 1 0 decap_w0
xfeed_20461 1 0 decap_w0
xfeed_20460 1 0 decap_w0
xfeed_18779 1 0 decap_w0
xfeed_18778 1 0 decap_w0
xfeed_18777 1 0 decap_w0
xfeed_18776 1 0 decap_w0
xfeed_18775 1 0 decap_w0
xfeed_18774 1 0 decap_w0
xfeed_18773 1 0 decap_w0
xfeed_18772 1 0 decap_w0
xfeed_18771 1 0 decap_w0
xfeed_18770 1 0 decap_w0
xfeed_14469 1 0 decap_w0
xfeed_14468 1 0 decap_w0
xfeed_14467 1 0 decap_w0
xfeed_14466 1 0 decap_w0
xfeed_14465 1 0 decap_w0
xfeed_14464 1 0 decap_w0
xfeed_14463 1 0 decap_w0
xfeed_14462 1 0 decap_w0
xfeed_14461 1 0 decap_w0
xfeed_14460 1 0 decap_w0
xfeed_13939 1 0 decap_w0
xfeed_13938 1 0 decap_w0
xfeed_13937 1 0 decap_w0
xfeed_13936 1 0 decap_w0
xfeed_13935 1 0 decap_w0
xfeed_13934 1 0 decap_w0
xfeed_13933 1 0 decap_w0
xfeed_13932 1 0 decap_w0
xfeed_13931 1 0 decap_w0
xfeed_13930 1 0 decap_w0
xfeed_10159 1 0 decap_w0
xfeed_10158 1 0 decap_w0
xfeed_10157 1 0 decap_w0
xfeed_10156 1 0 decap_w0
xfeed_10155 1 0 decap_w0
xfeed_10154 1 0 decap_w0
xfeed_10153 1 0 decap_w0
xfeed_10152 1 0 decap_w0
xfeed_10151 1 0 decap_w0
xfeed_10150 1 0 decap_w0
xfeed_789 1 0 decap_w0
xfeed_788 1 0 decap_w0
xfeed_787 1 0 decap_w0
xfeed_786 1 0 decap_w0
xfeed_785 1 0 decap_w0
xfeed_784 1 0 decap_w0
xfeed_783 1 0 decap_w0
xfeed_782 1 0 decap_w0
xfeed_781 1 0 decap_w0
xfeed_780 1 0 decap_w0
xfeed_30786 1 0 decap_w0
xfeed_30785 1 0 decap_w0
xfeed_30784 1 0 decap_w0
xfeed_30783 1 0 decap_w0
xfeed_30782 1 0 decap_w0
xfeed_30781 1 0 decap_w0
xfeed_30780 1 0 decap_w0
xfeed_8269 1 0 decap_w0
xfeed_8268 1 0 decap_w0
xfeed_8267 1 0 decap_w0
xfeed_8266 1 0 decap_w0
xfeed_8265 1 0 decap_w0
xfeed_8264 1 0 decap_w0
xfeed_8263 1 0 decap_w0
xfeed_8262 1 0 decap_w0
xfeed_8261 1 0 decap_w0
xfeed_8260 1 0 decap_w0
xfeed_7739 1 0 decap_w0
xfeed_7738 1 0 decap_w0
xfeed_7737 1 0 decap_w0
xfeed_7736 1 0 decap_w0
xfeed_7735 1 0 decap_w0
xfeed_7734 1 0 tie
xfeed_7733 1 0 decap_w0
xfeed_7732 1 0 decap_w0
xfeed_7731 1 0 decap_w0
xfeed_7730 1 0 decap_w0
xfeed_3429 1 0 decap_w0
xfeed_3428 1 0 decap_w0
xfeed_3427 1 0 decap_w0
xfeed_3426 1 0 decap_w0
xfeed_3425 1 0 decap_w0
xfeed_3424 1 0 decap_w0
xfeed_3423 1 0 decap_w0
xfeed_3422 1 0 decap_w0
xfeed_3421 1 0 decap_w0
xfeed_3420 1 0 decap_w0
xfeed_30789 1 0 decap_w0
xfeed_30788 1 0 decap_w0
xfeed_30787 1 0 decap_w0
xfeed_29709 1 0 decap_w0
xfeed_29708 1 0 decap_w0
xfeed_29707 1 0 decap_w0
xfeed_29706 1 0 decap_w0
xfeed_29705 1 0 decap_w0
xfeed_29704 1 0 decap_w0
xfeed_29703 1 0 decap_w0
xfeed_29702 1 0 decap_w0
xfeed_29701 1 0 decap_w0
xfeed_29700 1 0 decap_w0
xfeed_24789 1 0 decap_w0
xfeed_24788 1 0 decap_w0
xfeed_24787 1 0 decap_w0
xfeed_24786 1 0 decap_w0
xfeed_24785 1 0 decap_w0
xfeed_24784 1 0 decap_w0
xfeed_24783 1 0 decap_w0
xfeed_24782 1 0 decap_w0
xfeed_24781 1 0 decap_w0
xfeed_24780 1 0 decap_w0
xfeed_20479 1 0 decap_w0
xfeed_20478 1 0 decap_w0
xfeed_20477 1 0 decap_w0
xfeed_20476 1 0 decap_w0
xfeed_20475 1 0 decap_w0
xfeed_20474 1 0 decap_w0
xfeed_20473 1 0 decap_w0
xfeed_20472 1 0 decap_w0
xfeed_20471 1 0 decap_w0
xfeed_20470 1 0 decap_w0
xfeed_18789 1 0 decap_w0
xfeed_18788 1 0 decap_w0
xfeed_18787 1 0 decap_w0
xfeed_18786 1 0 decap_w0
xfeed_18785 1 0 decap_w0
xfeed_18784 1 0 decap_w0
xfeed_18783 1 0 decap_w0
xfeed_18782 1 0 decap_w0
xfeed_18781 1 0 decap_w0
xfeed_18780 1 0 decap_w0
xfeed_14479 1 0 decap_w0
xfeed_14478 1 0 decap_w0
xfeed_14477 1 0 decap_w0
xfeed_14476 1 0 decap_w0
xfeed_14475 1 0 decap_w0
xfeed_14474 1 0 decap_w0
xfeed_14473 1 0 decap_w0
xfeed_14472 1 0 decap_w0
xfeed_14471 1 0 decap_w0
xfeed_14470 1 0 decap_w0
xfeed_13949 1 0 decap_w0
xfeed_13948 1 0 decap_w0
xfeed_13947 1 0 decap_w0
xfeed_13946 1 0 decap_w0
xfeed_13945 1 0 decap_w0
xfeed_13944 1 0 decap_w0
xfeed_13943 1 0 decap_w0
xfeed_13942 1 0 decap_w0
xfeed_13941 1 0 decap_w0
xfeed_13940 1 0 decap_w0
xfeed_10169 1 0 decap_w0
xfeed_10168 1 0 decap_w0
xfeed_10167 1 0 decap_w0
xfeed_10166 1 0 decap_w0
xfeed_10165 1 0 decap_w0
xfeed_10164 1 0 decap_w0
xfeed_10163 1 0 decap_w0
xfeed_10162 1 0 decap_w0
xfeed_10161 1 0 decap_w0
xfeed_10160 1 0 decap_w0
xfeed_799 1 0 decap_w0
xfeed_798 1 0 decap_w0
xfeed_797 1 0 decap_w0
xfeed_796 1 0 decap_w0
xfeed_795 1 0 decap_w0
xfeed_794 1 0 decap_w0
xfeed_793 1 0 decap_w0
xfeed_792 1 0 decap_w0
xfeed_791 1 0 decap_w0
xfeed_790 1 0 decap_w0
xfeed_31409 1 0 decap_w0
xfeed_31408 1 0 decap_w0
xfeed_31407 1 0 decap_w0
xfeed_31406 1 0 decap_w0
xfeed_31405 1 0 decap_w0
xfeed_31404 1 0 decap_w0
xfeed_31403 1 0 decap_w0
xfeed_31402 1 0 decap_w0
xfeed_31401 1 0 decap_w0
xfeed_31400 1 0 decap_w0
xfeed_30793 1 0 decap_w0
xfeed_30792 1 0 decap_w0
xfeed_30791 1 0 decap_w0
xfeed_30790 1 0 decap_w0
xfeed_25403 1 0 decap_w0
xfeed_25402 1 0 decap_w0
xfeed_25401 1 0 decap_w0
xfeed_25400 1 0 decap_w0
xfeed_8279 1 0 decap_w0
xfeed_8278 1 0 decap_w0
xfeed_8277 1 0 decap_w0
xfeed_8276 1 0 decap_w0
xfeed_8275 1 0 decap_w0
xfeed_8274 1 0 decap_w0
xfeed_8273 1 0 decap_w0
xfeed_8272 1 0 decap_w0
xfeed_8271 1 0 decap_w0
xfeed_8270 1 0 decap_w0
xfeed_7749 1 0 decap_w0
xfeed_7748 1 0 decap_w0
xfeed_7747 1 0 decap_w0
xfeed_7746 1 0 decap_w0
xfeed_7745 1 0 decap_w0
xfeed_7744 1 0 decap_w0
xfeed_7743 1 0 decap_w0
xfeed_7742 1 0 decap_w0
xfeed_7741 1 0 decap_w0
xfeed_7740 1 0 decap_w0
xfeed_3439 1 0 decap_w0
xfeed_3438 1 0 decap_w0
xfeed_3437 1 0 decap_w0
xfeed_3436 1 0 decap_w0
xfeed_3435 1 0 decap_w0
xfeed_3434 1 0 decap_w0
xfeed_3433 1 0 decap_w0
xfeed_3432 1 0 decap_w0
xfeed_3431 1 0 decap_w0
xfeed_3430 1 0 decap_w0
xfeed_2909 1 0 decap_w0
xfeed_2908 1 0 decap_w0
xfeed_2907 1 0 decap_w0
xfeed_2906 1 0 decap_w0
xfeed_2905 1 0 decap_w0
xfeed_2904 1 0 decap_w0
xfeed_2903 1 0 decap_w0
xfeed_2902 1 0 decap_w0
xfeed_2901 1 0 decap_w0
xfeed_2900 1 0 decap_w0
xsubckt_27_xor2_x0 1 0 36 58 121 xor2_x0
xfeed_30799 1 0 decap_w0
xfeed_30798 1 0 decap_w0
xfeed_30797 1 0 decap_w0
xfeed_30796 1 0 decap_w0
xfeed_30795 1 0 decap_w0
xfeed_30794 1 0 decap_w0
xfeed_29719 1 0 decap_w0
xfeed_29718 1 0 decap_w0
xfeed_29717 1 0 decap_w0
xfeed_29716 1 0 decap_w0
xfeed_29715 1 0 decap_w0
xfeed_29714 1 0 decap_w0
xfeed_29713 1 0 decap_w0
xfeed_29712 1 0 decap_w0
xfeed_29711 1 0 decap_w0
xfeed_29710 1 0 decap_w0
xfeed_25409 1 0 decap_w0
xfeed_25408 1 0 decap_w0
xfeed_25407 1 0 decap_w0
xfeed_25406 1 0 decap_w0
xfeed_25405 1 0 decap_w0
xfeed_25404 1 0 decap_w0
xfeed_24799 1 0 decap_w0
xfeed_24798 1 0 decap_w0
xfeed_24797 1 0 decap_w0
xfeed_24796 1 0 decap_w0
xfeed_24795 1 0 decap_w0
xfeed_24794 1 0 decap_w0
xfeed_24793 1 0 decap_w0
xfeed_24792 1 0 decap_w0
xfeed_24791 1 0 decap_w0
xfeed_24790 1 0 decap_w0
xfeed_20489 1 0 decap_w0
xfeed_20488 1 0 decap_w0
xfeed_20487 1 0 decap_w0
xfeed_20486 1 0 decap_w0
xfeed_20485 1 0 decap_w0
xfeed_20484 1 0 decap_w0
xfeed_20483 1 0 decap_w0
xfeed_20482 1 0 decap_w0
xfeed_20481 1 0 decap_w0
xfeed_20480 1 0 decap_w0
xfeed_19409 1 0 decap_w0
xfeed_19408 1 0 decap_w0
xfeed_19407 1 0 decap_w0
xfeed_19406 1 0 decap_w0
xfeed_19405 1 0 decap_w0
xfeed_19404 1 0 decap_w0
xfeed_19403 1 0 decap_w0
xfeed_19402 1 0 decap_w0
xfeed_19401 1 0 decap_w0
xfeed_19400 1 0 decap_w0
xfeed_18799 1 0 decap_w0
xfeed_18798 1 0 decap_w0
xfeed_18797 1 0 decap_w0
xfeed_18796 1 0 decap_w0
xfeed_18795 1 0 decap_w0
xfeed_18794 1 0 decap_w0
xfeed_18793 1 0 decap_w0
xfeed_18792 1 0 decap_w0
xfeed_18791 1 0 decap_w0
xfeed_18790 1 0 decap_w0
xfeed_14489 1 0 decap_w0
xfeed_14488 1 0 decap_w0
xfeed_14487 1 0 decap_w0
xfeed_14486 1 0 decap_w0
xfeed_14485 1 0 decap_w0
xfeed_14484 1 0 decap_w0
xfeed_14483 1 0 decap_w0
xfeed_14482 1 0 decap_w0
xfeed_14481 1 0 decap_w0
xfeed_14480 1 0 decap_w0
xfeed_13959 1 0 decap_w0
xfeed_13958 1 0 decap_w0
xfeed_13957 1 0 decap_w0
xfeed_13956 1 0 decap_w0
xfeed_13955 1 0 decap_w0
xfeed_13954 1 0 decap_w0
xfeed_13953 1 0 decap_w0
xfeed_13952 1 0 decap_w0
xfeed_13951 1 0 decap_w0
xfeed_13950 1 0 decap_w0
xfeed_10179 1 0 decap_w0
xfeed_10178 1 0 decap_w0
xfeed_10177 1 0 decap_w0
xfeed_10176 1 0 decap_w0
xfeed_10175 1 0 decap_w0
xfeed_10174 1 0 decap_w0
xfeed_10173 1 0 decap_w0
xfeed_10172 1 0 decap_w0
xfeed_10171 1 0 decap_w0
xfeed_10170 1 0 decap_w0
xfeed_31419 1 0 decap_w0
xfeed_31418 1 0 decap_w0
xfeed_31417 1 0 decap_w0
xfeed_31416 1 0 decap_w0
xfeed_31415 1 0 decap_w0
xfeed_31414 1 0 decap_w0
xfeed_31413 1 0 decap_w0
xfeed_31412 1 0 decap_w0
xfeed_31411 1 0 decap_w0
xfeed_31410 1 0 decap_w0
xfeed_25410 1 0 decap_w0
xfeed_21109 1 0 decap_w0
xfeed_21108 1 0 decap_w0
xfeed_21107 1 0 decap_w0
xfeed_21106 1 0 decap_w0
xfeed_21105 1 0 decap_w0
xfeed_21104 1 0 decap_w0
xfeed_21103 1 0 decap_w0
xfeed_21102 1 0 decap_w0
xfeed_21101 1 0 decap_w0
xfeed_21100 1 0 decap_w0
xfeed_8289 1 0 decap_w0
xfeed_8288 1 0 decap_w0
xfeed_8287 1 0 decap_w0
xfeed_8286 1 0 decap_w0
xfeed_8285 1 0 decap_w0
xfeed_8284 1 0 decap_w0
xfeed_8283 1 0 decap_w0
xfeed_8282 1 0 decap_w0
xfeed_8281 1 0 decap_w0
xfeed_8280 1 0 decap_w0
xfeed_7759 1 0 decap_w0
xfeed_7758 1 0 decap_w0
xfeed_7757 1 0 decap_w0
xfeed_7756 1 0 decap_w0
xfeed_7755 1 0 decap_w0
xfeed_7754 1 0 decap_w0
xfeed_7753 1 0 decap_w0
xfeed_7752 1 0 decap_w0
xfeed_7751 1 0 decap_w0
xfeed_7750 1 0 decap_w0
xfeed_3449 1 0 decap_w0
xfeed_3448 1 0 decap_w0
xfeed_3447 1 0 decap_w0
xfeed_3446 1 0 decap_w0
xfeed_3445 1 0 decap_w0
xfeed_3444 1 0 decap_w0
xfeed_3443 1 0 decap_w0
xfeed_3442 1 0 decap_w0
xfeed_3441 1 0 decap_w0
xfeed_3440 1 0 decap_w0
xfeed_2919 1 0 decap_w0
xfeed_2918 1 0 decap_w0
xfeed_2917 1 0 decap_w0
xfeed_2916 1 0 decap_w0
xfeed_2915 1 0 decap_w0
xfeed_2914 1 0 decap_w0
xfeed_2913 1 0 decap_w0
xfeed_2912 1 0 decap_w0
xfeed_2911 1 0 decap_w0
xfeed_2910 1 0 decap_w0
xfeed_29729 1 0 decap_w0
xfeed_29727 1 0 decap_w0
xfeed_29726 1 0 decap_w0
xfeed_29725 1 0 decap_w0
xfeed_29724 1 0 decap_w0
xfeed_29723 1 0 decap_w0
xfeed_29722 1 0 decap_w0
xfeed_29721 1 0 decap_w0
xfeed_29720 1 0 decap_w0
xfeed_25419 1 0 decap_w0
xfeed_25418 1 0 decap_w0
xfeed_25417 1 0 decap_w0
xfeed_25416 1 0 decap_w0
xfeed_25415 1 0 decap_w0
xfeed_25414 1 0 decap_w0
xfeed_25413 1 0 decap_w0
xfeed_25412 1 0 decap_w0
xfeed_25411 1 0 decap_w0
xfeed_20499 1 0 decap_w0
xfeed_20498 1 0 decap_w0
xfeed_20497 1 0 decap_w0
xfeed_20496 1 0 decap_w0
xfeed_20495 1 0 decap_w0
xfeed_20494 1 0 decap_w0
xfeed_20493 1 0 decap_w0
xfeed_20492 1 0 decap_w0
xfeed_20491 1 0 decap_w0
xfeed_20490 1 0 decap_w0
xfeed_19419 1 0 decap_w0
xfeed_19418 1 0 decap_w0
xfeed_19417 1 0 decap_w0
xfeed_19416 1 0 decap_w0
xfeed_19415 1 0 decap_w0
xfeed_19414 1 0 decap_w0
xfeed_19413 1 0 decap_w0
xfeed_19412 1 0 decap_w0
xfeed_19411 1 0 decap_w0
xfeed_19410 1 0 decap_w0
xfeed_15109 1 0 decap_w0
xfeed_15108 1 0 decap_w0
xfeed_15107 1 0 decap_w0
xfeed_15106 1 0 decap_w0
xfeed_15105 1 0 decap_w0
xfeed_15104 1 0 decap_w0
xfeed_15103 1 0 decap_w0
xfeed_15102 1 0 decap_w0
xfeed_15101 1 0 decap_w0
xfeed_15100 1 0 decap_w0
xfeed_14499 1 0 decap_w0
xfeed_14498 1 0 decap_w0
xfeed_14497 1 0 decap_w0
xfeed_14496 1 0 decap_w0
xfeed_14495 1 0 decap_w0
xfeed_14494 1 0 decap_w0
xfeed_14493 1 0 decap_w0
xfeed_14492 1 0 decap_w0
xfeed_14491 1 0 decap_w0
xfeed_14490 1 0 decap_w0
xfeed_13969 1 0 decap_w0
xfeed_13968 1 0 decap_w0
xfeed_13967 1 0 decap_w0
xfeed_13966 1 0 decap_w0
xfeed_13965 1 0 decap_w0
xfeed_13964 1 0 decap_w0
xfeed_13963 1 0 decap_w0
xfeed_13962 1 0 decap_w0
xfeed_13961 1 0 decap_w0
xfeed_13960 1 0 decap_w0
xfeed_10189 1 0 decap_w0
xfeed_10188 1 0 decap_w0
xfeed_10187 1 0 decap_w0
xfeed_10186 1 0 decap_w0
xfeed_10185 1 0 decap_w0
xfeed_10184 1 0 decap_w0
xfeed_10183 1 0 decap_w0
xfeed_10182 1 0 decap_w0
xfeed_10181 1 0 decap_w0
xfeed_10180 1 0 decap_w0
xfeed_31429 1 0 decap_w0
xfeed_31428 1 0 decap_w0
xfeed_31427 1 0 decap_w0
xfeed_31426 1 0 decap_w0
xfeed_31425 1 0 decap_w0
xfeed_31424 1 0 decap_w0
xfeed_31423 1 0 decap_w0
xfeed_31422 1 0 decap_w0
xfeed_31421 1 0 decap_w0
xfeed_31420 1 0 decap_w0
xfeed_21117 1 0 decap_w0
xfeed_21116 1 0 decap_w0
xfeed_21115 1 0 decap_w0
xfeed_21114 1 0 decap_w0
xfeed_21113 1 0 decap_w0
xfeed_21112 1 0 decap_w0
xfeed_21111 1 0 decap_w0
xfeed_21110 1 0 decap_w0
xfeed_8299 1 0 decap_w0
xfeed_8298 1 0 decap_w0
xfeed_8297 1 0 decap_w0
xfeed_8296 1 0 decap_w0
xfeed_8295 1 0 decap_w0
xfeed_8294 1 0 decap_w0
xfeed_8293 1 0 decap_w0
xfeed_8292 1 0 decap_w0
xfeed_8291 1 0 decap_w0
xfeed_8290 1 0 decap_w0
xfeed_7769 1 0 decap_w0
xfeed_7768 1 0 decap_w0
xfeed_7767 1 0 decap_w0
xfeed_7766 1 0 decap_w0
xfeed_7765 1 0 decap_w0
xfeed_7764 1 0 decap_w0
xfeed_7763 1 0 decap_w0
xfeed_7762 1 0 decap_w0
xfeed_7761 1 0 decap_w0
xfeed_7760 1 0 decap_w0
xfeed_3459 1 0 decap_w0
xfeed_3458 1 0 decap_w0
xfeed_3457 1 0 decap_w0
xfeed_3456 1 0 decap_w0
xfeed_3455 1 0 decap_w0
xfeed_3454 1 0 decap_w0
xfeed_3453 1 0 decap_w0
xfeed_3452 1 0 decap_w0
xfeed_3451 1 0 decap_w0
xfeed_3450 1 0 decap_w0
xfeed_2929 1 0 decap_w0
xfeed_2928 1 0 decap_w0
xfeed_2927 1 0 decap_w0
xfeed_2926 1 0 decap_w0
xfeed_2925 1 0 decap_w0
xfeed_2924 1 0 decap_w0
xfeed_2923 1 0 decap_w0
xfeed_2922 1 0 decap_w0
xfeed_2921 1 0 decap_w0
xfeed_2920 1 0 decap_w0
xfeed_29739 1 0 decap_w0
xfeed_29738 1 0 decap_w0
xfeed_29737 1 0 decap_w0
xfeed_29736 1 0 decap_w0
xfeed_29735 1 0 decap_w0
xfeed_29734 1 0 decap_w0
xfeed_29733 1 0 decap_w0
xfeed_29732 1 0 decap_w0
xfeed_29731 1 0 decap_w0
xfeed_29730 1 0 decap_w0
xfeed_25429 1 0 decap_w0
xfeed_25428 1 0 decap_w0
xfeed_25427 1 0 decap_w0
xfeed_25426 1 0 decap_w0
xfeed_25425 1 0 decap_w0
xfeed_25424 1 0 decap_w0
xfeed_25423 1 0 decap_w0
xfeed_25422 1 0 decap_w0
xfeed_25421 1 0 decap_w0
xfeed_25420 1 0 decap_w0
xfeed_21119 1 0 decap_w0
xfeed_21118 1 0 decap_w0
xfeed_19429 1 0 decap_w0
xfeed_19428 1 0 decap_w0
xfeed_19427 1 0 decap_w0
xfeed_19426 1 0 decap_w0
xfeed_19425 1 0 decap_w0
xfeed_19424 1 0 decap_w0
xfeed_19423 1 0 decap_w0
xfeed_19422 1 0 decap_w0
xfeed_19421 1 0 decap_w0
xfeed_19420 1 0 decap_w0
xfeed_15119 1 0 decap_w0
xfeed_15118 1 0 decap_w0
xfeed_15117 1 0 decap_w0
xfeed_15116 1 0 decap_w0
xfeed_15115 1 0 decap_w0
xfeed_15114 1 0 decap_w0
xfeed_15113 1 0 decap_w0
xfeed_15112 1 0 decap_w0
xfeed_15111 1 0 decap_w0
xfeed_15110 1 0 decap_w0
xfeed_13978 1 0 decap_w0
xfeed_13977 1 0 decap_w0
xfeed_13976 1 0 tie
xfeed_13975 1 0 decap_w0
xfeed_13974 1 0 decap_w0
xfeed_13973 1 0 decap_w0
xfeed_13972 1 0 decap_w0
xfeed_13971 1 0 decap_w0
xfeed_13970 1 0 decap_w0
xfeed_10199 1 0 decap_w0
xfeed_10198 1 0 decap_w0
xfeed_10197 1 0 decap_w0
xfeed_10196 1 0 decap_w0
xfeed_10195 1 0 decap_w0
xfeed_10194 1 0 decap_w0
xfeed_10193 1 0 decap_w0
xfeed_10192 1 0 decap_w0
xfeed_10191 1 0 decap_w0
xfeed_10190 1 0 decap_w0
xfeed_900 1 0 decap_w0
xfeed_901 1 0 decap_w0
xfeed_902 1 0 decap_w0
xfeed_903 1 0 decap_w0
xfeed_904 1 0 decap_w0
xfeed_905 1 0 decap_w0
xfeed_906 1 0 decap_w0
xfeed_907 1 0 decap_w0
xfeed_908 1 0 decap_w0
xfeed_909 1 0 decap_w0
xfeed_31439 1 0 decap_w0
xfeed_31438 1 0 decap_w0
xfeed_31437 1 0 decap_w0
xfeed_31436 1 0 decap_w0
xfeed_31435 1 0 decap_w0
xfeed_31434 1 0 decap_w0
xfeed_31433 1 0 decap_w0
xfeed_31432 1 0 decap_w0
xfeed_31431 1 0 decap_w0
xfeed_31430 1 0 decap_w0
xfeed_30909 1 0 decap_w0
xfeed_30908 1 0 decap_w0
xfeed_30907 1 0 decap_w0
xfeed_30906 1 0 decap_w0
xfeed_30905 1 0 decap_w0
xfeed_30904 1 0 decap_w0
xfeed_30903 1 0 decap_w0
xfeed_30902 1 0 decap_w0
xfeed_30901 1 0 decap_w0
xfeed_30900 1 0 decap_w0
xfeed_21124 1 0 decap_w0
xfeed_21123 1 0 decap_w0
xfeed_21122 1 0 decap_w0
xfeed_21121 1 0 decap_w0
xfeed_21120 1 0 decap_w0
xfeed_13979 1 0 decap_w0
xfeed_7779 1 0 decap_w0
xfeed_7778 1 0 decap_w0
xfeed_7777 1 0 decap_w0
xfeed_7776 1 0 decap_w0
xfeed_7775 1 0 decap_w0
xfeed_7774 1 0 decap_w0
xfeed_7773 1 0 decap_w0
xfeed_7772 1 0 decap_w0
xfeed_7771 1 0 decap_w0
xfeed_7770 1 0 decap_w0
xfeed_3469 1 0 decap_w0
xfeed_3468 1 0 decap_w0
xfeed_3467 1 0 decap_w0
xfeed_3466 1 0 decap_w0
xfeed_3465 1 0 decap_w0
xfeed_3464 1 0 decap_w0
xfeed_3463 1 0 decap_w0
xfeed_3462 1 0 decap_w0
xfeed_3461 1 0 decap_w0
xfeed_3460 1 0 decap_w0
xfeed_2939 1 0 decap_w0
xfeed_2938 1 0 decap_w0
xfeed_2937 1 0 decap_w0
xfeed_2936 1 0 decap_w0
xfeed_2935 1 0 decap_w0
xfeed_2934 1 0 decap_w0
xfeed_2933 1 0 decap_w0
xfeed_2932 1 0 decap_w0
xfeed_2931 1 0 decap_w0
xfeed_2930 1 0 decap_w0
xfeed_29749 1 0 decap_w0
xfeed_29748 1 0 decap_w0
xfeed_29747 1 0 decap_w0
xfeed_29746 1 0 decap_w0
xfeed_29745 1 0 decap_w0
xfeed_29744 1 0 decap_w0
xfeed_29743 1 0 decap_w0
xfeed_29742 1 0 decap_w0
xfeed_29741 1 0 decap_w0
xfeed_29740 1 0 decap_w0
xfeed_25439 1 0 decap_w0
xfeed_25438 1 0 decap_w0
xfeed_25437 1 0 decap_w0
xfeed_25436 1 0 decap_w0
xfeed_25435 1 0 decap_w0
xfeed_25434 1 0 decap_w0
xfeed_25433 1 0 decap_w0
xfeed_25432 1 0 decap_w0
xfeed_25431 1 0 decap_w0
xfeed_25430 1 0 decap_w0
xfeed_24909 1 0 decap_w0
xfeed_24908 1 0 decap_w0
xfeed_24907 1 0 decap_w0
xfeed_24906 1 0 decap_w0
xfeed_24905 1 0 decap_w0
xfeed_24904 1 0 decap_w0
xfeed_24903 1 0 decap_w0
xfeed_24902 1 0 decap_w0
xfeed_24901 1 0 decap_w0
xfeed_24900 1 0 decap_w0
xfeed_21129 1 0 decap_w0
xfeed_21128 1 0 decap_w0
xfeed_21127 1 0 decap_w0
xfeed_21126 1 0 decap_w0
xfeed_21125 1 0 decap_w0
xfeed_19439 1 0 decap_w0
xfeed_19438 1 0 decap_w0
xfeed_19437 1 0 decap_w0
xfeed_19436 1 0 decap_w0
xfeed_19435 1 0 decap_w0
xfeed_19434 1 0 decap_w0
xfeed_19433 1 0 decap_w0
xfeed_19432 1 0 decap_w0
xfeed_19431 1 0 decap_w0
xfeed_19430 1 0 decap_w0
xfeed_18909 1 0 decap_w0
xfeed_18908 1 0 tie
xfeed_18907 1 0 decap_w0
xfeed_18906 1 0 decap_w0
xfeed_18905 1 0 decap_w0
xfeed_18904 1 0 decap_w0
xfeed_18903 1 0 decap_w0
xfeed_18902 1 0 decap_w0
xfeed_18901 1 0 decap_w0
xfeed_18900 1 0 decap_w0
xfeed_15129 1 0 decap_w0
xfeed_15128 1 0 decap_w0
xfeed_15127 1 0 decap_w0
xfeed_15126 1 0 decap_w0
xfeed_15125 1 0 decap_w0
xfeed_15124 1 0 decap_w0
xfeed_15123 1 0 decap_w0
xfeed_15122 1 0 decap_w0
xfeed_15121 1 0 decap_w0
xfeed_15120 1 0 decap_w0
xfeed_13985 1 0 decap_w0
xfeed_13984 1 0 decap_w0
xfeed_13983 1 0 decap_w0
xfeed_13982 1 0 decap_w0
xfeed_13981 1 0 decap_w0
xfeed_13980 1 0 decap_w0
xfeed_910 1 0 decap_w0
xfeed_911 1 0 decap_w0
xfeed_912 1 0 decap_w0
xfeed_913 1 0 decap_w0
xfeed_914 1 0 decap_w0
xfeed_915 1 0 decap_w0
xfeed_916 1 0 decap_w0
xfeed_917 1 0 decap_w0
xfeed_918 1 0 decap_w0
xfeed_919 1 0 decap_w0
xfeed_31449 1 0 decap_w0
xfeed_31448 1 0 decap_w0
xfeed_31447 1 0 decap_w0
xfeed_31446 1 0 decap_w0
xfeed_31445 1 0 decap_w0
xfeed_31444 1 0 decap_w0
xfeed_31443 1 0 decap_w0
xfeed_31442 1 0 decap_w0
xfeed_31441 1 0 decap_w0
xfeed_31440 1 0 decap_w0
xfeed_30919 1 0 decap_w0
xfeed_30918 1 0 decap_w0
xfeed_30917 1 0 decap_w0
xfeed_30916 1 0 decap_w0
xfeed_30915 1 0 decap_w0
xfeed_30914 1 0 decap_w0
xfeed_30913 1 0 decap_w0
xfeed_30912 1 0 decap_w0
xfeed_30911 1 0 decap_w0
xfeed_30910 1 0 decap_w0
xfeed_21131 1 0 decap_w0
xfeed_21130 1 0 decap_w0
xfeed_13989 1 0 decap_w0
xfeed_13988 1 0 decap_w0
xfeed_13987 1 0 decap_w0
xfeed_13986 1 0 decap_w0
xfeed_7789 1 0 decap_w0
xfeed_7788 1 0 decap_w0
xfeed_7787 1 0 decap_w0
xfeed_7786 1 0 decap_w0
xfeed_7785 1 0 decap_w0
xfeed_7784 1 0 decap_w0
xfeed_7783 1 0 decap_w0
xfeed_7782 1 0 decap_w0
xfeed_7781 1 0 decap_w0
xfeed_7780 1 0 decap_w0
xfeed_3479 1 0 decap_w0
xfeed_3478 1 0 decap_w0
xfeed_3477 1 0 decap_w0
xfeed_3476 1 0 decap_w0
xfeed_3475 1 0 decap_w0
xfeed_3474 1 0 decap_w0
xfeed_3473 1 0 decap_w0
xfeed_3472 1 0 decap_w0
xfeed_3471 1 0 decap_w0
xfeed_3470 1 0 decap_w0
xfeed_2949 1 0 decap_w0
xfeed_2948 1 0 decap_w0
xfeed_2947 1 0 decap_w0
xfeed_2946 1 0 decap_w0
xfeed_2945 1 0 decap_w0
xfeed_2944 1 0 decap_w0
xfeed_2943 1 0 decap_w0
xfeed_2942 1 0 decap_w0
xfeed_2941 1 0 decap_w0
xfeed_2940 1 0 decap_w0
xfeed_29759 1 0 decap_w0
xfeed_29758 1 0 decap_w0
xfeed_29757 1 0 decap_w0
xfeed_29756 1 0 decap_w0
xfeed_29755 1 0 decap_w0
xfeed_29754 1 0 decap_w0
xfeed_29753 1 0 decap_w0
xfeed_29752 1 0 decap_w0
xfeed_29751 1 0 decap_w0
xfeed_29750 1 0 decap_w0
xfeed_25449 1 0 decap_w0
xfeed_25448 1 0 decap_w0
xfeed_25447 1 0 decap_w0
xfeed_25446 1 0 decap_w0
xfeed_25445 1 0 decap_w0
xfeed_25444 1 0 decap_w0
xfeed_25443 1 0 decap_w0
xfeed_25442 1 0 decap_w0
xfeed_25441 1 0 decap_w0
xfeed_25440 1 0 decap_w0
xfeed_24919 1 0 decap_w0
xfeed_24918 1 0 decap_w0
xfeed_24917 1 0 decap_w0
xfeed_24916 1 0 decap_w0
xfeed_24915 1 0 decap_w0
xfeed_24914 1 0 decap_w0
xfeed_24913 1 0 decap_w0
xfeed_24912 1 0 decap_w0
xfeed_24911 1 0 decap_w0
xfeed_24910 1 0 decap_w0
xfeed_21139 1 0 decap_w0
xfeed_21138 1 0 decap_w0
xfeed_21137 1 0 decap_w0
xfeed_21136 1 0 decap_w0
xfeed_21135 1 0 decap_w0
xfeed_21134 1 0 decap_w0
xfeed_21133 1 0 decap_w0
xfeed_21132 1 0 decap_w0
xfeed_20609 1 0 decap_w0
xfeed_20608 1 0 decap_w0
xfeed_20607 1 0 decap_w0
xfeed_20606 1 0 decap_w0
xfeed_20605 1 0 decap_w0
xfeed_20604 1 0 decap_w0
xfeed_20603 1 0 decap_w0
xfeed_20602 1 0 decap_w0
xfeed_20601 1 0 decap_w0
xfeed_20600 1 0 decap_w0
xfeed_19449 1 0 decap_w0
xfeed_19448 1 0 decap_w0
xfeed_19447 1 0 decap_w0
xfeed_19446 1 0 decap_w0
xfeed_19445 1 0 decap_w0
xfeed_19444 1 0 decap_w0
xfeed_19443 1 0 decap_w0
xfeed_19442 1 0 decap_w0
xfeed_19441 1 0 decap_w0
xfeed_19440 1 0 decap_w0
xfeed_18919 1 0 decap_w0
xfeed_18918 1 0 decap_w0
xfeed_18917 1 0 decap_w0
xfeed_18916 1 0 decap_w0
xfeed_18915 1 0 decap_w0
xfeed_18914 1 0 decap_w0
xfeed_18913 1 0 decap_w0
xfeed_18912 1 0 decap_w0
xfeed_18911 1 0 decap_w0
xfeed_18910 1 0 decap_w0
xfeed_15139 1 0 decap_w0
xfeed_15138 1 0 decap_w0
xfeed_15137 1 0 decap_w0
xfeed_15136 1 0 decap_w0
xfeed_15135 1 0 decap_w0
xfeed_15134 1 0 decap_w0
xfeed_15133 1 0 decap_w0
xfeed_15132 1 0 decap_w0
xfeed_15131 1 0 decap_w0
xfeed_15130 1 0 decap_w0
xfeed_14609 1 0 decap_w0
xfeed_14608 1 0 decap_w0
xfeed_14607 1 0 decap_w0
xfeed_14606 1 0 decap_w0
xfeed_14605 1 0 decap_w0
xfeed_14604 1 0 decap_w0
xfeed_14603 1 0 decap_w0
xfeed_14602 1 0 decap_w0
xfeed_14601 1 0 decap_w0
xfeed_14600 1 0 decap_w0
xfeed_13992 1 0 decap_w0
xfeed_13991 1 0 decap_w0
xfeed_13990 1 0 decap_w0
xfeed_920 1 0 decap_w0
xfeed_921 1 0 decap_w0
xfeed_922 1 0 decap_w0
xfeed_923 1 0 decap_w0
xfeed_924 1 0 decap_w0
xfeed_925 1 0 decap_w0
xfeed_926 1 0 decap_w0
xfeed_927 1 0 decap_w0
xfeed_928 1 0 decap_w0
xfeed_929 1 0 decap_w0
xfeed_31459 1 0 decap_w0
xfeed_31458 1 0 decap_w0
xfeed_31457 1 0 decap_w0
xfeed_31456 1 0 decap_w0
xfeed_31455 1 0 decap_w0
xfeed_31454 1 0 decap_w0
xfeed_31453 1 0 decap_w0
xfeed_31452 1 0 decap_w0
xfeed_31451 1 0 decap_w0
xfeed_31450 1 0 decap_w0
xfeed_30926 1 0 decap_w0
xfeed_30925 1 0 decap_w0
xfeed_30924 1 0 decap_w0
xfeed_30923 1 0 decap_w0
xfeed_30922 1 0 decap_w0
xfeed_30921 1 0 decap_w0
xfeed_30920 1 0 decap_w0
xfeed_13999 1 0 decap_w0
xfeed_13998 1 0 decap_w0
xfeed_13997 1 0 decap_w0
xfeed_13996 1 0 decap_w0
xfeed_13995 1 0 decap_w0
xfeed_13994 1 0 decap_w0
xfeed_13993 1 0 decap_w0
xfeed_8409 1 0 decap_w0
xfeed_8408 1 0 decap_w0
xfeed_8407 1 0 decap_w0
xfeed_8406 1 0 decap_w0
xfeed_8405 1 0 decap_w0
xfeed_8404 1 0 decap_w0
xfeed_8403 1 0 decap_w0
xfeed_8402 1 0 decap_w0
xfeed_8401 1 0 decap_w0
xfeed_8400 1 0 decap_w0
xfeed_7799 1 0 decap_w0
xfeed_7798 1 0 decap_w0
xfeed_7797 1 0 decap_w0
xfeed_7796 1 0 decap_w0
xfeed_7795 1 0 decap_w0
xfeed_7794 1 0 decap_w0
xfeed_7793 1 0 decap_w0
xfeed_7792 1 0 decap_w0
xfeed_7791 1 0 decap_w0
xfeed_7790 1 0 decap_w0
xfeed_3489 1 0 decap_w0
xfeed_3488 1 0 decap_w0
xfeed_3487 1 0 decap_w0
xfeed_3486 1 0 decap_w0
xfeed_3485 1 0 decap_w0
xfeed_3484 1 0 decap_w0
xfeed_3483 1 0 decap_w0
xfeed_3482 1 0 decap_w0
xfeed_3481 1 0 decap_w0
xfeed_3480 1 0 decap_w0
xfeed_2959 1 0 decap_w0
xfeed_2958 1 0 decap_w0
xfeed_2957 1 0 decap_w0
xfeed_2956 1 0 decap_w0
xfeed_2955 1 0 decap_w0
xfeed_2954 1 0 decap_w0
xfeed_2953 1 0 decap_w0
xfeed_2952 1 0 decap_w0
xfeed_2951 1 0 decap_w0
xfeed_2950 1 0 decap_w0
xfeed_30929 1 0 decap_w0
xfeed_30928 1 0 decap_w0
xfeed_30927 1 0 decap_w0
xfeed_29769 1 0 decap_w0
xfeed_29768 1 0 decap_w0
xfeed_29767 1 0 decap_w0
xfeed_29766 1 0 decap_w0
xfeed_29765 1 0 decap_w0
xfeed_29764 1 0 decap_w0
xfeed_29763 1 0 decap_w0
xfeed_29762 1 0 decap_w0
xfeed_29761 1 0 decap_w0
xfeed_29760 1 0 decap_w0
xfeed_25459 1 0 decap_w0
xfeed_25458 1 0 decap_w0
xfeed_25457 1 0 decap_w0
xfeed_25456 1 0 decap_w0
xfeed_25455 1 0 decap_w0
xfeed_25454 1 0 decap_w0
xfeed_25453 1 0 decap_w0
xfeed_25452 1 0 decap_w0
xfeed_25451 1 0 decap_w0
xfeed_25450 1 0 decap_w0
xfeed_24929 1 0 decap_w0
xfeed_24928 1 0 decap_w0
xfeed_24927 1 0 decap_w0
xfeed_24926 1 0 decap_w0
xfeed_24925 1 0 decap_w0
xfeed_24924 1 0 decap_w0
xfeed_24923 1 0 decap_w0
xfeed_24922 1 0 decap_w0
xfeed_24921 1 0 decap_w0
xfeed_24920 1 0 decap_w0
xfeed_21149 1 0 decap_w0
xfeed_21148 1 0 decap_w0
xfeed_21147 1 0 decap_w0
xfeed_21146 1 0 decap_w0
xfeed_21145 1 0 decap_w0
xfeed_21144 1 0 decap_w0
xfeed_21143 1 0 decap_w0
xfeed_21142 1 0 decap_w0
xfeed_21141 1 0 decap_w0
xfeed_21140 1 0 decap_w0
xfeed_20619 1 0 decap_w0
xfeed_20618 1 0 decap_w0
xfeed_20617 1 0 decap_w0
xfeed_20616 1 0 decap_w0
xfeed_20615 1 0 decap_w0
xfeed_20614 1 0 decap_w0
xfeed_20613 1 0 decap_w0
xfeed_20612 1 0 decap_w0
xfeed_20611 1 0 decap_w0
xfeed_20610 1 0 decap_w0
xfeed_19459 1 0 decap_w0
xfeed_19458 1 0 decap_w0
xfeed_19457 1 0 decap_w0
xfeed_19456 1 0 decap_w0
xfeed_19455 1 0 decap_w0
xfeed_19454 1 0 decap_w0
xfeed_19453 1 0 decap_w0
xfeed_19452 1 0 decap_w0
xfeed_19451 1 0 decap_w0
xfeed_19450 1 0 decap_w0
xfeed_18929 1 0 decap_w0
xfeed_18928 1 0 decap_w0
xfeed_18927 1 0 decap_w0
xfeed_18926 1 0 decap_w0
xfeed_18925 1 0 decap_w0
xfeed_18924 1 0 decap_w0
xfeed_18923 1 0 decap_w0
xfeed_18922 1 0 decap_w0
xfeed_18921 1 0 decap_w0
xfeed_18920 1 0 decap_w0
xfeed_15149 1 0 decap_w0
xfeed_15148 1 0 decap_w0
xfeed_15147 1 0 decap_w0
xfeed_15146 1 0 decap_w0
xfeed_15145 1 0 decap_w0
xfeed_15144 1 0 decap_w0
xfeed_15143 1 0 decap_w0
xfeed_15142 1 0 decap_w0
xfeed_15141 1 0 decap_w0
xfeed_15140 1 0 decap_w0
xfeed_14619 1 0 decap_w0
xfeed_14618 1 0 decap_w0
xfeed_14617 1 0 decap_w0
xfeed_14616 1 0 decap_w0
xfeed_14615 1 0 decap_w0
xfeed_14614 1 0 decap_w0
xfeed_14613 1 0 decap_w0
xfeed_14612 1 0 decap_w0
xfeed_14611 1 0 decap_w0
xfeed_14610 1 0 decap_w0
xfeed_10309 1 0 decap_w0
xfeed_10308 1 0 decap_w0
xfeed_10307 1 0 decap_w0
xfeed_10306 1 0 decap_w0
xfeed_10305 1 0 decap_w0
xfeed_10304 1 0 decap_w0
xfeed_10303 1 0 decap_w0
xfeed_10302 1 0 decap_w0
xfeed_10301 1 0 decap_w0
xfeed_10300 1 0 decap_w0
xfeed_930 1 0 decap_w0
xfeed_931 1 0 decap_w0
xfeed_932 1 0 decap_w0
xfeed_933 1 0 decap_w0
xfeed_934 1 0 decap_w0
xfeed_935 1 0 decap_w0
xfeed_936 1 0 decap_w0
xfeed_937 1 0 decap_w0
xfeed_938 1 0 decap_w0
xfeed_939 1 0 decap_w0
xfeed_31469 1 0 decap_w0
xfeed_31468 1 0 decap_w0
xfeed_31467 1 0 decap_w0
xfeed_31466 1 0 decap_w0
xfeed_31465 1 0 decap_w0
xfeed_31464 1 0 decap_w0
xfeed_31463 1 0 decap_w0
xfeed_31462 1 0 decap_w0
xfeed_31461 1 0 decap_w0
xfeed_31460 1 0 decap_w0
xfeed_30933 1 0 decap_w0
xfeed_30932 1 0 decap_w0
xfeed_30931 1 0 decap_w0
xfeed_30930 1 0 decap_w0
xfeed_8419 1 0 decap_w0
xfeed_8418 1 0 decap_w0
xfeed_8417 1 0 decap_w0
xfeed_8416 1 0 decap_w0
xfeed_8415 1 0 decap_w0
xfeed_8414 1 0 decap_w0
xfeed_8413 1 0 decap_w0
xfeed_8412 1 0 decap_w0
xfeed_8411 1 0 decap_w0
xfeed_8410 1 0 decap_w0
xfeed_4109 1 0 decap_w0
xfeed_4108 1 0 decap_w0
xfeed_4107 1 0 decap_w0
xfeed_4106 1 0 decap_w0
xfeed_4105 1 0 decap_w0
xfeed_4104 1 0 decap_w0
xfeed_4103 1 0 decap_w0
xfeed_4102 1 0 decap_w0
xfeed_4101 1 0 decap_w0
xfeed_4100 1 0 decap_w0
xfeed_3499 1 0 decap_w0
xfeed_3498 1 0 decap_w0
xfeed_3497 1 0 decap_w0
xfeed_3496 1 0 decap_w0
xfeed_3495 1 0 decap_w0
xfeed_3494 1 0 decap_w0
xfeed_3493 1 0 decap_w0
xfeed_3492 1 0 decap_w0
xfeed_3491 1 0 decap_w0
xfeed_3490 1 0 decap_w0
xfeed_2969 1 0 decap_w0
xfeed_2968 1 0 decap_w0
xfeed_2967 1 0 decap_w0
xfeed_2966 1 0 decap_w0
xfeed_2965 1 0 decap_w0
xfeed_2964 1 0 decap_w0
xfeed_2963 1 0 decap_w0
xfeed_2962 1 0 decap_w0
xfeed_2961 1 0 decap_w0
xfeed_2960 1 0 decap_w0
xfeed_30939 1 0 decap_w0
xfeed_30938 1 0 decap_w0
xfeed_30937 1 0 decap_w0
xfeed_30936 1 0 decap_w0
xfeed_30935 1 0 decap_w0
xfeed_30934 1 0 decap_w0
xfeed_29779 1 0 decap_w0
xfeed_29778 1 0 decap_w0
xfeed_29777 1 0 decap_w0
xfeed_29776 1 0 decap_w0
xfeed_29775 1 0 decap_w0
xfeed_29774 1 0 decap_w0
xfeed_29773 1 0 decap_w0
xfeed_29772 1 0 decap_w0
xfeed_29771 1 0 decap_w0
xfeed_29770 1 0 decap_w0
xfeed_25469 1 0 decap_w0
xfeed_25468 1 0 decap_w0
xfeed_25467 1 0 decap_w0
xfeed_25466 1 0 decap_w0
xfeed_25465 1 0 decap_w0
xfeed_25464 1 0 decap_w0
xfeed_25463 1 0 decap_w0
xfeed_25462 1 0 decap_w0
xfeed_25461 1 0 decap_w0
xfeed_25460 1 0 decap_w0
xfeed_24939 1 0 decap_w0
xfeed_24938 1 0 decap_w0
xfeed_24937 1 0 decap_w0
xfeed_24936 1 0 decap_w0
xfeed_24935 1 0 decap_w0
xfeed_24934 1 0 decap_w0
xfeed_24933 1 0 decap_w0
xfeed_24932 1 0 decap_w0
xfeed_24931 1 0 decap_w0
xfeed_24930 1 0 decap_w0
xfeed_21159 1 0 decap_w0
xfeed_21158 1 0 decap_w0
xfeed_21157 1 0 decap_w0
xfeed_21156 1 0 decap_w0
xfeed_21155 1 0 decap_w0
xfeed_21154 1 0 decap_w0
xfeed_21153 1 0 decap_w0
xfeed_21152 1 0 decap_w0
xfeed_21151 1 0 decap_w0
xfeed_21150 1 0 decap_w0
xfeed_20629 1 0 decap_w0
xfeed_20628 1 0 decap_w0
xfeed_20627 1 0 decap_w0
xfeed_20626 1 0 decap_w0
xfeed_20625 1 0 decap_w0
xfeed_20624 1 0 decap_w0
xfeed_20623 1 0 decap_w0
xfeed_20622 1 0 decap_w0
xfeed_20621 1 0 decap_w0
xfeed_20620 1 0 decap_w0
xfeed_19469 1 0 decap_w0
xfeed_19468 1 0 decap_w0
xfeed_19467 1 0 decap_w0
xfeed_19466 1 0 decap_w0
xfeed_19465 1 0 decap_w0
xfeed_19464 1 0 decap_w0
xfeed_19463 1 0 decap_w0
xfeed_19462 1 0 decap_w0
xfeed_19461 1 0 decap_w0
xfeed_19460 1 0 decap_w0
xfeed_18939 1 0 decap_w0
xfeed_18938 1 0 decap_w0
xfeed_18937 1 0 decap_w0
xfeed_18936 1 0 decap_w0
xfeed_18935 1 0 decap_w0
xfeed_18934 1 0 decap_w0
xfeed_18933 1 0 decap_w0
xfeed_18932 1 0 decap_w0
xfeed_18931 1 0 decap_w0
xfeed_18930 1 0 decap_w0
xfeed_15159 1 0 decap_w0
xfeed_15158 1 0 decap_w0
xfeed_15157 1 0 decap_w0
xfeed_15156 1 0 decap_w0
xfeed_15155 1 0 decap_w0
xfeed_15154 1 0 decap_w0
xfeed_15153 1 0 decap_w0
xfeed_15152 1 0 decap_w0
xfeed_15151 1 0 decap_w0
xfeed_15150 1 0 decap_w0
xfeed_14629 1 0 decap_w0
xfeed_14628 1 0 decap_w0
xfeed_14627 1 0 decap_w0
xfeed_14626 1 0 decap_w0
xfeed_14625 1 0 decap_w0
xfeed_14624 1 0 decap_w0
xfeed_14623 1 0 decap_w0
xfeed_14622 1 0 decap_w0
xfeed_14621 1 0 decap_w0
xfeed_14620 1 0 decap_w0
xfeed_10319 1 0 decap_w0
xfeed_10318 1 0 decap_w0
xfeed_10317 1 0 decap_w0
xfeed_10316 1 0 decap_w0
xfeed_10315 1 0 decap_w0
xfeed_10314 1 0 decap_w0
xfeed_10313 1 0 decap_w0
xfeed_10312 1 0 decap_w0
xfeed_10311 1 0 decap_w0
xfeed_10310 1 0 decap_w0
xfeed_940 1 0 decap_w0
xfeed_941 1 0 decap_w0
xfeed_942 1 0 decap_w0
xfeed_943 1 0 decap_w0
xfeed_944 1 0 decap_w0
xfeed_945 1 0 decap_w0
xfeed_946 1 0 decap_w0
xfeed_947 1 0 decap_w0
xfeed_948 1 0 decap_w0
xfeed_949 1 0 decap_w0
xfeed_31479 1 0 decap_w0
xfeed_31478 1 0 decap_w0
xfeed_31477 1 0 decap_w0
xfeed_31476 1 0 decap_w0
xfeed_31475 1 0 decap_w0
xfeed_31474 1 0 decap_w0
xfeed_31473 1 0 decap_w0
xfeed_31472 1 0 decap_w0
xfeed_31471 1 0 decap_w0
xfeed_31470 1 0 decap_w0
xfeed_30940 1 0 decap_w0
xfeed_8429 1 0 decap_w0
xfeed_8428 1 0 decap_w0
xfeed_8427 1 0 decap_w0
xfeed_8426 1 0 decap_w0
xfeed_8425 1 0 decap_w0
xfeed_8424 1 0 decap_w0
xfeed_8423 1 0 decap_w0
xfeed_8422 1 0 decap_w0
xfeed_8421 1 0 decap_w0
xfeed_8420 1 0 decap_w0
xfeed_4119 1 0 decap_w0
xfeed_4118 1 0 decap_w0
xfeed_4117 1 0 decap_w0
xfeed_4116 1 0 decap_w0
xfeed_4115 1 0 decap_w0
xfeed_4114 1 0 decap_w0
xfeed_4113 1 0 decap_w0
xfeed_4112 1 0 decap_w0
xfeed_4111 1 0 decap_w0
xfeed_4110 1 0 decap_w0
xfeed_2979 1 0 decap_w0
xfeed_2978 1 0 decap_w0
xfeed_2977 1 0 decap_w0
xfeed_2976 1 0 decap_w0
xfeed_2975 1 0 decap_w0
xfeed_2974 1 0 decap_w0
xfeed_2973 1 0 decap_w0
xfeed_2972 1 0 decap_w0
xfeed_2971 1 0 decap_w0
xfeed_2970 1 0 decap_w0
xsubckt_33_inv_x0 1 0 117 23 inv_x0
xfeed_30949 1 0 decap_w0
xfeed_30948 1 0 decap_w0
xfeed_30947 1 0 decap_w0
xfeed_30946 1 0 decap_w0
xfeed_30945 1 0 decap_w0
xfeed_30944 1 0 decap_w0
xfeed_30943 1 0 decap_w0
xfeed_30942 1 0 decap_w0
xfeed_30941 1 0 decap_w0
xfeed_29789 1 0 decap_w0
xfeed_29788 1 0 decap_w0
xfeed_29787 1 0 decap_w0
xfeed_29786 1 0 decap_w0
xfeed_29785 1 0 decap_w0
xfeed_29784 1 0 decap_w0
xfeed_29783 1 0 decap_w0
xfeed_29782 1 0 decap_w0
xfeed_29781 1 0 decap_w0
xfeed_29780 1 0 decap_w0
xfeed_25479 1 0 decap_w0
xfeed_25478 1 0 decap_w0
xfeed_25477 1 0 decap_w0
xfeed_25476 1 0 decap_w0
xfeed_25475 1 0 decap_w0
xfeed_25474 1 0 decap_w0
xfeed_25473 1 0 decap_w0
xfeed_25472 1 0 decap_w0
xfeed_25471 1 0 decap_w0
xfeed_25470 1 0 decap_w0
xfeed_24949 1 0 decap_w0
xfeed_24948 1 0 decap_w0
xfeed_24947 1 0 decap_w0
xfeed_24946 1 0 decap_w0
xfeed_24945 1 0 decap_w0
xfeed_24944 1 0 decap_w0
xfeed_24943 1 0 decap_w0
xfeed_24942 1 0 decap_w0
xfeed_24941 1 0 decap_w0
xfeed_24940 1 0 decap_w0
xfeed_21169 1 0 decap_w0
xfeed_21168 1 0 decap_w0
xfeed_21167 1 0 decap_w0
xfeed_21166 1 0 decap_w0
xfeed_21165 1 0 decap_w0
xfeed_21164 1 0 decap_w0
xfeed_21163 1 0 decap_w0
xfeed_21162 1 0 decap_w0
xfeed_21161 1 0 decap_w0
xfeed_21160 1 0 decap_w0
xfeed_20639 1 0 decap_w0
xfeed_20638 1 0 decap_w0
xfeed_20637 1 0 decap_w0
xfeed_20636 1 0 decap_w0
xfeed_20635 1 0 decap_w0
xfeed_20634 1 0 decap_w0
xfeed_20633 1 0 decap_w0
xfeed_20632 1 0 decap_w0
xfeed_20631 1 0 decap_w0
xfeed_20630 1 0 decap_w0
xfeed_19479 1 0 decap_w0
xfeed_19478 1 0 decap_w0
xfeed_19477 1 0 decap_w0
xfeed_19476 1 0 decap_w0
xfeed_19475 1 0 decap_w0
xfeed_19474 1 0 decap_w0
xfeed_19473 1 0 decap_w0
xfeed_19472 1 0 decap_w0
xfeed_19471 1 0 decap_w0
xfeed_19470 1 0 decap_w0
xfeed_18949 1 0 decap_w0
xfeed_18948 1 0 decap_w0
xfeed_18947 1 0 decap_w0
xfeed_18946 1 0 decap_w0
xfeed_18945 1 0 decap_w0
xfeed_18944 1 0 decap_w0
xfeed_18943 1 0 decap_w0
xfeed_18942 1 0 decap_w0
xfeed_18941 1 0 decap_w0
xfeed_18940 1 0 decap_w0
xfeed_15169 1 0 decap_w0
xfeed_15168 1 0 decap_w0
xfeed_15167 1 0 decap_w0
xfeed_15166 1 0 decap_w0
xfeed_15165 1 0 decap_w0
xfeed_15164 1 0 decap_w0
xfeed_15163 1 0 decap_w0
xfeed_15162 1 0 decap_w0
xfeed_15161 1 0 decap_w0
xfeed_15160 1 0 decap_w0
xfeed_14639 1 0 decap_w0
xfeed_14638 1 0 decap_w0
xfeed_14637 1 0 decap_w0
xfeed_14636 1 0 decap_w0
xfeed_14635 1 0 decap_w0
xfeed_14634 1 0 decap_w0
xfeed_14633 1 0 decap_w0
xfeed_14632 1 0 decap_w0
xfeed_14631 1 0 decap_w0
xfeed_14630 1 0 decap_w0
xfeed_10329 1 0 decap_w0
xfeed_10327 1 0 tie
xfeed_10326 1 0 decap_w0
xfeed_10325 1 0 decap_w0
xfeed_10324 1 0 decap_w0
xfeed_10323 1 0 decap_w0
xfeed_10322 1 0 decap_w0
xfeed_10321 1 0 decap_w0
xfeed_10320 1 0 decap_w0
xsubckt_100_nexor2_x0 1 0 139 9 8 nexor2_x0
xfeed_950 1 0 decap_w0
xfeed_951 1 0 decap_w0
xfeed_952 1 0 decap_w0
xfeed_953 1 0 decap_w0
xfeed_954 1 0 decap_w0
xfeed_955 1 0 decap_w0
xfeed_956 1 0 decap_w0
xfeed_957 1 0 decap_w0
xfeed_958 1 0 decap_w0
xfeed_959 1 0 decap_w0
xfeed_31486 1 0 decap_w0
xfeed_31485 1 0 decap_w0
xfeed_31484 1 0 decap_w0
xfeed_31483 1 0 decap_w0
xfeed_31482 1 0 decap_w0
xfeed_31481 1 0 decap_w0
xfeed_31480 1 0 decap_w0
xfeed_8439 1 0 decap_w0
xfeed_8438 1 0 decap_w0
xfeed_8437 1 0 decap_w0
xfeed_8436 1 0 decap_w0
xfeed_8435 1 0 decap_w0
xfeed_8434 1 0 decap_w0
xfeed_8433 1 0 decap_w0
xfeed_8432 1 0 decap_w0
xfeed_8431 1 0 decap_w0
xfeed_8430 1 0 decap_w0
xfeed_7909 1 0 decap_w0
xfeed_7908 1 0 decap_w0
xfeed_7907 1 0 decap_w0
xfeed_7906 1 0 decap_w0
xfeed_7905 1 0 decap_w0
xfeed_7904 1 0 decap_w0
xfeed_7903 1 0 decap_w0
xfeed_7902 1 0 decap_w0
xfeed_7901 1 0 decap_w0
xfeed_7900 1 0 decap_w0
xfeed_4129 1 0 decap_w0
xfeed_4128 1 0 decap_w0
xfeed_4127 1 0 decap_w0
xfeed_4126 1 0 decap_w0
xfeed_4125 1 0 decap_w0
xfeed_4124 1 0 decap_w0
xfeed_4123 1 0 decap_w0
xfeed_4122 1 0 decap_w0
xfeed_4121 1 0 decap_w0
xfeed_4120 1 0 decap_w0
xfeed_2989 1 0 decap_w0
xfeed_2988 1 0 decap_w0
xfeed_2987 1 0 decap_w0
xfeed_2986 1 0 decap_w0
xfeed_2985 1 0 decap_w0
xfeed_2984 1 0 decap_w0
xfeed_2983 1 0 decap_w0
xfeed_2982 1 0 decap_w0
xfeed_2981 1 0 decap_w0
xfeed_2980 1 0 decap_w0
xsubckt_4_xor2_x0 1 0 47 56 136 xor2_x0
xfeed_31489 1 0 decap_w0
xfeed_31488 1 0 decap_w0
xfeed_31487 1 0 decap_w0
xfeed_30959 1 0 decap_w0
xfeed_30958 1 0 decap_w0
xfeed_30957 1 0 decap_w0
xfeed_30956 1 0 decap_w0
xfeed_30955 1 0 decap_w0
xfeed_30954 1 0 decap_w0
xfeed_30953 1 0 decap_w0
xfeed_30952 1 0 decap_w0
xfeed_30951 1 0 decap_w0
xfeed_30950 1 0 decap_w0
xfeed_29799 1 0 decap_w0
xfeed_29798 1 0 decap_w0
xfeed_29797 1 0 decap_w0
xfeed_29796 1 0 decap_w0
xfeed_29795 1 0 decap_w0
xfeed_29794 1 0 decap_w0
xfeed_29793 1 0 decap_w0
xfeed_29792 1 0 decap_w0
xfeed_29791 1 0 decap_w0
xfeed_29790 1 0 decap_w0
xfeed_25489 1 0 decap_w0
xfeed_25488 1 0 decap_w0
xfeed_25487 1 0 decap_w0
xfeed_25486 1 0 decap_w0
xfeed_25485 1 0 decap_w0
xfeed_25484 1 0 decap_w0
xfeed_25483 1 0 decap_w0
xfeed_25482 1 0 decap_w0
xfeed_25481 1 0 decap_w0
xfeed_25480 1 0 decap_w0
xfeed_24959 1 0 decap_w0
xfeed_24958 1 0 decap_w0
xfeed_24957 1 0 decap_w0
xfeed_24956 1 0 decap_w0
xfeed_24955 1 0 decap_w0
xfeed_24954 1 0 decap_w0
xfeed_24953 1 0 decap_w0
xfeed_24952 1 0 decap_w0
xfeed_24951 1 0 decap_w0
xfeed_24950 1 0 decap_w0
xfeed_21179 1 0 decap_w0
xfeed_21178 1 0 decap_w0
xfeed_21177 1 0 decap_w0
xfeed_21176 1 0 decap_w0
xfeed_21175 1 0 decap_w0
xfeed_21174 1 0 decap_w0
xfeed_21173 1 0 decap_w0
xfeed_21172 1 0 decap_w0
xfeed_21171 1 0 decap_w0
xfeed_21170 1 0 decap_w0
xfeed_20649 1 0 decap_w0
xfeed_20648 1 0 decap_w0
xfeed_20647 1 0 decap_w0
xfeed_20646 1 0 decap_w0
xfeed_20645 1 0 decap_w0
xfeed_20644 1 0 decap_w0
xfeed_20643 1 0 decap_w0
xfeed_20642 1 0 decap_w0
xfeed_20641 1 0 decap_w0
xfeed_20640 1 0 decap_w0
xfeed_19489 1 0 decap_w0
xfeed_19488 1 0 decap_w0
xfeed_19487 1 0 decap_w0
xfeed_19486 1 0 decap_w0
xfeed_19485 1 0 decap_w0
xfeed_19484 1 0 decap_w0
xfeed_19483 1 0 decap_w0
xfeed_19482 1 0 decap_w0
xfeed_19481 1 0 decap_w0
xfeed_19480 1 0 decap_w0
xfeed_18957 1 0 decap_w0
xfeed_18956 1 0 decap_w0
xfeed_18955 1 0 decap_w0
xfeed_18954 1 0 decap_w0
xfeed_18953 1 0 decap_w0
xfeed_18952 1 0 decap_w0
xfeed_18951 1 0 decap_w0
xfeed_18950 1 0 decap_w0
xfeed_15179 1 0 decap_w0
xfeed_15178 1 0 decap_w0
xfeed_15177 1 0 decap_w0
xfeed_15176 1 0 decap_w0
xfeed_15175 1 0 decap_w0
xfeed_15174 1 0 decap_w0
xfeed_15173 1 0 decap_w0
xfeed_15172 1 0 decap_w0
xfeed_15171 1 0 decap_w0
xfeed_15170 1 0 decap_w0
xfeed_14649 1 0 decap_w0
xfeed_14648 1 0 decap_w0
xfeed_14647 1 0 decap_w0
xfeed_14646 1 0 decap_w0
xfeed_14645 1 0 decap_w0
xfeed_14644 1 0 decap_w0
xfeed_14643 1 0 decap_w0
xfeed_14642 1 0 decap_w0
xfeed_14641 1 0 decap_w0
xfeed_14640 1 0 decap_w0
xfeed_10339 1 0 decap_w0
xfeed_10338 1 0 decap_w0
xfeed_10337 1 0 decap_w0
xfeed_10336 1 0 decap_w0
xfeed_10335 1 0 decap_w0
xfeed_10334 1 0 decap_w0
xfeed_10333 1 0 decap_w0
xfeed_10332 1 0 decap_w0
xfeed_10331 1 0 decap_w0
xfeed_10330 1 0 decap_w0
xfeed_960 1 0 decap_w0
xfeed_961 1 0 decap_w0
xfeed_962 1 0 decap_w0
xfeed_963 1 0 decap_w0
xfeed_964 1 0 decap_w0
xfeed_965 1 0 decap_w0
xfeed_966 1 0 decap_w0
xfeed_967 1 0 decap_w0
xfeed_968 1 0 decap_w0
xfeed_969 1 0 decap_w0
xfeed_32109 1 0 tie
xfeed_32108 1 0 tie
xfeed_32107 1 0 tie
xfeed_32106 1 0 tie
xfeed_32105 1 0 tie
xfeed_32103 1 0 tie
xfeed_32102 1 0 tie
xfeed_32101 1 0 decap_w0
xfeed_32100 1 0 decap_w0
xfeed_31493 1 0 decap_w0
xfeed_31492 1 0 decap_w0
xfeed_31491 1 0 decap_w0
xfeed_31490 1 0 decap_w0
xfeed_26103 1 0 decap_w0
xfeed_26102 1 0 decap_w0
xfeed_26101 1 0 decap_w0
xfeed_26100 1 0 decap_w0
xfeed_18959 1 0 decap_w0
xfeed_18958 1 0 decap_w0
xfeed_8449 1 0 decap_w0
xfeed_8448 1 0 decap_w0
xfeed_8447 1 0 decap_w0
xfeed_8446 1 0 decap_w0
xfeed_8445 1 0 decap_w0
xfeed_8444 1 0 decap_w0
xfeed_8443 1 0 decap_w0
xfeed_8442 1 0 decap_w0
xfeed_8441 1 0 decap_w0
xfeed_8440 1 0 decap_w0
xfeed_7919 1 0 decap_w0
xfeed_7918 1 0 decap_w0
xfeed_7917 1 0 decap_w0
xfeed_7916 1 0 decap_w0
xfeed_7915 1 0 decap_w0
xfeed_7914 1 0 decap_w0
xfeed_7913 1 0 decap_w0
xfeed_7912 1 0 decap_w0
xfeed_7911 1 0 decap_w0
xfeed_7910 1 0 decap_w0
xfeed_4139 1 0 decap_w0
xfeed_4138 1 0 decap_w0
xfeed_4137 1 0 decap_w0
xfeed_4136 1 0 decap_w0
xfeed_4135 1 0 decap_w0
xfeed_4134 1 0 decap_w0
xfeed_4133 1 0 decap_w0
xfeed_4132 1 0 decap_w0
xfeed_4131 1 0 decap_w0
xfeed_4130 1 0 decap_w0
xfeed_3609 1 0 decap_w0
xfeed_3608 1 0 decap_w0
xfeed_3607 1 0 decap_w0
xfeed_3606 1 0 decap_w0
xfeed_3605 1 0 decap_w0
xfeed_3604 1 0 decap_w0
xfeed_3603 1 0 decap_w0
xfeed_3602 1 0 decap_w0
xfeed_3601 1 0 decap_w0
xfeed_3600 1 0 decap_w0
xfeed_2998 1 0 decap_w0
xfeed_2997 1 0 decap_w0
xfeed_2996 1 0 decap_w0
xfeed_2995 1 0 decap_w0
xfeed_2994 1 0 decap_w0
xfeed_2993 1 0 decap_w0
xfeed_2992 1 0 decap_w0
xfeed_2991 1 0 decap_w0
xfeed_2990 1 0 decap_w0
xfeed_31499 1 0 decap_w0
xfeed_31498 1 0 decap_w0
xfeed_31497 1 0 decap_w0
xfeed_31496 1 0 decap_w0
xfeed_31495 1 0 decap_w0
xfeed_31494 1 0 decap_w0
xfeed_30969 1 0 decap_w0
xfeed_30968 1 0 decap_w0
xfeed_30967 1 0 decap_w0
xfeed_30966 1 0 decap_w0
xfeed_30965 1 0 decap_w0
xfeed_30964 1 0 decap_w0
xfeed_30963 1 0 decap_w0
xfeed_30962 1 0 decap_w0
xfeed_30961 1 0 decap_w0
xfeed_30960 1 0 decap_w0
xfeed_26109 1 0 decap_w0
xfeed_26108 1 0 decap_w0
xfeed_26107 1 0 decap_w0
xfeed_26106 1 0 decap_w0
xfeed_26105 1 0 decap_w0
xfeed_26104 1 0 decap_w0
xfeed_25499 1 0 decap_w0
xfeed_25498 1 0 decap_w0
xfeed_25497 1 0 decap_w0
xfeed_25496 1 0 decap_w0
xfeed_25495 1 0 decap_w0
xfeed_25494 1 0 decap_w0
xfeed_25493 1 0 decap_w0
xfeed_25492 1 0 decap_w0
xfeed_25491 1 0 decap_w0
xfeed_25490 1 0 decap_w0
xfeed_24969 1 0 decap_w0
xfeed_24968 1 0 decap_w0
xfeed_24967 1 0 decap_w0
xfeed_24966 1 0 decap_w0
xfeed_24965 1 0 decap_w0
xfeed_24964 1 0 decap_w0
xfeed_24963 1 0 decap_w0
xfeed_24962 1 0 decap_w0
xfeed_24961 1 0 decap_w0
xfeed_24960 1 0 decap_w0
xfeed_21189 1 0 decap_w0
xfeed_21188 1 0 decap_w0
xfeed_21187 1 0 decap_w0
xfeed_21186 1 0 decap_w0
xfeed_21185 1 0 decap_w0
xfeed_21184 1 0 decap_w0
xfeed_21183 1 0 decap_w0
xfeed_21182 1 0 decap_w0
xfeed_21181 1 0 decap_w0
xfeed_21180 1 0 decap_w0
xfeed_20659 1 0 decap_w0
xfeed_20658 1 0 decap_w0
xfeed_20657 1 0 decap_w0
xfeed_20656 1 0 decap_w0
xfeed_20655 1 0 decap_w0
xfeed_20654 1 0 decap_w0
xfeed_20653 1 0 decap_w0
xfeed_20652 1 0 decap_w0
xfeed_20651 1 0 decap_w0
xfeed_20650 1 0 decap_w0
xfeed_19499 1 0 decap_w0
xfeed_19498 1 0 decap_w0
xfeed_19497 1 0 decap_w0
xfeed_19496 1 0 decap_w0
xfeed_19495 1 0 decap_w0
xfeed_19494 1 0 decap_w0
xfeed_19493 1 0 decap_w0
xfeed_19492 1 0 decap_w0
xfeed_19491 1 0 decap_w0
xfeed_19490 1 0 decap_w0
xfeed_18964 1 0 decap_w0
xfeed_18963 1 0 decap_w0
xfeed_18962 1 0 decap_w0
xfeed_18961 1 0 decap_w0
xfeed_18960 1 0 decap_w0
xfeed_15189 1 0 decap_w0
xfeed_15188 1 0 decap_w0
xfeed_15187 1 0 decap_w0
xfeed_15186 1 0 decap_w0
xfeed_15185 1 0 decap_w0
xfeed_15184 1 0 decap_w0
xfeed_15183 1 0 decap_w0
xfeed_15182 1 0 tie
xfeed_15181 1 0 decap_w0
xfeed_15180 1 0 decap_w0
xfeed_14659 1 0 decap_w0
xfeed_14658 1 0 decap_w0
xfeed_14657 1 0 decap_w0
xfeed_14656 1 0 decap_w0
xfeed_14655 1 0 decap_w0
xfeed_14654 1 0 decap_w0
xfeed_14653 1 0 decap_w0
xfeed_14652 1 0 decap_w0
xfeed_14651 1 0 decap_w0
xfeed_14650 1 0 decap_w0
xfeed_10349 1 0 decap_w0
xfeed_10348 1 0 decap_w0
xfeed_10347 1 0 decap_w0
xfeed_10346 1 0 decap_w0
xfeed_10345 1 0 decap_w0
xfeed_10344 1 0 decap_w0
xfeed_10343 1 0 decap_w0
xfeed_10342 1 0 decap_w0
xfeed_10341 1 0 decap_w0
xfeed_10340 1 0 decap_w0
xfeed_2999 1 0 decap_w0
xfeed_970 1 0 decap_w0
xfeed_971 1 0 decap_w0
xfeed_972 1 0 decap_w0
xfeed_973 1 0 decap_w0
xfeed_974 1 0 decap_w0
xfeed_975 1 0 decap_w0
xfeed_976 1 0 decap_w0
xfeed_977 1 0 decap_w0
xfeed_978 1 0 decap_w0
xfeed_979 1 0 decap_w0
xfeed_32118 1 0 tie
xfeed_32117 1 0 tie
xfeed_32116 1 0 tie
xfeed_32114 1 0 tie
xfeed_32113 1 0 tie
xfeed_32112 1 0 tie
xfeed_32111 1 0 tie
xfeed_32110 1 0 tie
xfeed_26110 1 0 decap_w0
xfeed_18969 1 0 decap_w0
xfeed_18968 1 0 decap_w0
xfeed_18967 1 0 decap_w0
xfeed_18966 1 0 decap_w0
xfeed_18965 1 0 decap_w0
xfeed_8459 1 0 decap_w0
xfeed_8458 1 0 decap_w0
xfeed_8457 1 0 decap_w0
xfeed_8456 1 0 decap_w0
xfeed_8455 1 0 decap_w0
xfeed_8454 1 0 decap_w0
xfeed_8453 1 0 decap_w0
xfeed_8452 1 0 decap_w0
xfeed_8451 1 0 decap_w0
xfeed_8450 1 0 decap_w0
xfeed_7929 1 0 decap_w0
xfeed_7928 1 0 decap_w0
xfeed_7927 1 0 decap_w0
xfeed_7926 1 0 decap_w0
xfeed_7925 1 0 decap_w0
xfeed_7924 1 0 decap_w0
xfeed_7923 1 0 decap_w0
xfeed_7922 1 0 decap_w0
xfeed_7921 1 0 decap_w0
xfeed_7920 1 0 decap_w0
xfeed_4149 1 0 decap_w0
xfeed_4148 1 0 decap_w0
xfeed_4147 1 0 decap_w0
xfeed_4146 1 0 decap_w0
xfeed_4145 1 0 decap_w0
xfeed_4144 1 0 decap_w0
xfeed_4143 1 0 decap_w0
xfeed_4142 1 0 decap_w0
xfeed_4141 1 0 decap_w0
xfeed_4140 1 0 tie
xfeed_3619 1 0 decap_w0
xfeed_3618 1 0 decap_w0
xfeed_3617 1 0 decap_w0
xfeed_3616 1 0 decap_w0
xfeed_3615 1 0 decap_w0
xfeed_3614 1 0 decap_w0
xfeed_3613 1 0 decap_w0
xfeed_3612 1 0 decap_w0
xfeed_3611 1 0 decap_w0
xfeed_3610 1 0 decap_w0
xsubckt_71_xor2_x0 1 0 55 63 160 xor2_x0
xfeed_30979 1 0 decap_w0
xfeed_30978 1 0 decap_w0
xfeed_30977 1 0 decap_w0
xfeed_30976 1 0 decap_w0
xfeed_30975 1 0 decap_w0
xfeed_30974 1 0 decap_w0
xfeed_30973 1 0 decap_w0
xfeed_30972 1 0 decap_w0
xfeed_30971 1 0 decap_w0
xfeed_30970 1 0 decap_w0
xfeed_26119 1 0 decap_w0
xfeed_26118 1 0 decap_w0
xfeed_26117 1 0 decap_w0
xfeed_26116 1 0 decap_w0
xfeed_26115 1 0 decap_w0
xfeed_26114 1 0 decap_w0
xfeed_26113 1 0 decap_w0
xfeed_26112 1 0 decap_w0
xfeed_26111 1 0 decap_w0
xfeed_24979 1 0 decap_w0
xfeed_24978 1 0 decap_w0
xfeed_24977 1 0 decap_w0
xfeed_24976 1 0 decap_w0
xfeed_24975 1 0 decap_w0
xfeed_24974 1 0 decap_w0
xfeed_24973 1 0 decap_w0
xfeed_24972 1 0 decap_w0
xfeed_24971 1 0 decap_w0
xfeed_24970 1 0 decap_w0
xfeed_21199 1 0 decap_w0
xfeed_21198 1 0 decap_w0
xfeed_21197 1 0 decap_w0
xfeed_21196 1 0 decap_w0
xfeed_21195 1 0 decap_w0
xfeed_21194 1 0 decap_w0
xfeed_21193 1 0 decap_w0
xfeed_21192 1 0 decap_w0
xfeed_21191 1 0 decap_w0
xfeed_21190 1 0 decap_w0
xfeed_20669 1 0 decap_w0
xfeed_20668 1 0 decap_w0
xfeed_20667 1 0 decap_w0
xfeed_20666 1 0 decap_w0
xfeed_20665 1 0 decap_w0
xfeed_20664 1 0 decap_w0
xfeed_20663 1 0 decap_w0
xfeed_20662 1 0 decap_w0
xfeed_20661 1 0 decap_w0
xfeed_20660 1 0 decap_w0
xfeed_18971 1 0 decap_w0
xfeed_18970 1 0 decap_w0
xfeed_15199 1 0 decap_w0
xfeed_15198 1 0 decap_w0
xfeed_15197 1 0 decap_w0
xfeed_15196 1 0 decap_w0
xfeed_15195 1 0 decap_w0
xfeed_15194 1 0 decap_w0
xfeed_15193 1 0 decap_w0
xfeed_15192 1 0 decap_w0
xfeed_15191 1 0 decap_w0
xfeed_15190 1 0 decap_w0
xfeed_14669 1 0 decap_w0
xfeed_14668 1 0 decap_w0
xfeed_14667 1 0 decap_w0
xfeed_14666 1 0 decap_w0
xfeed_14665 1 0 decap_w0
xfeed_14664 1 0 decap_w0
xfeed_14663 1 0 decap_w0
xfeed_14662 1 0 decap_w0
xfeed_14661 1 0 decap_w0
xfeed_14660 1 0 decap_w0
xfeed_10359 1 0 decap_w0
xfeed_10357 1 0 decap_w0
xfeed_10356 1 0 decap_w0
xfeed_10355 1 0 decap_w0
xfeed_10354 1 0 decap_w0
xfeed_10353 1 0 decap_w0
xfeed_10352 1 0 decap_w0
xfeed_10351 1 0 decap_w0
xfeed_10350 1 0 decap_w0
xfeed_980 1 0 decap_w0
xfeed_981 1 0 decap_w0
xfeed_982 1 0 decap_w0
xfeed_983 1 0 decap_w0
xfeed_984 1 0 decap_w0
xfeed_985 1 0 decap_w0
xfeed_986 1 0 decap_w0
xfeed_987 1 0 decap_w0
xfeed_988 1 0 decap_w0
xfeed_989 1 0 decap_w0
xfeed_18979 1 0 decap_w0
xfeed_18978 1 0 decap_w0
xfeed_18977 1 0 decap_w0
xfeed_18976 1 0 decap_w0
xfeed_18975 1 0 decap_w0
xfeed_18974 1 0 decap_w0
xfeed_18973 1 0 decap_w0
xfeed_18972 1 0 decap_w0
xfeed_8469 1 0 decap_w0
xfeed_8468 1 0 decap_w0
xfeed_8467 1 0 decap_w0
xfeed_8466 1 0 decap_w0
xfeed_8465 1 0 decap_w0
xfeed_8464 1 0 decap_w0
xfeed_8463 1 0 decap_w0
xfeed_8462 1 0 decap_w0
xfeed_8461 1 0 decap_w0
xfeed_8460 1 0 decap_w0
xfeed_7939 1 0 decap_w0
xfeed_7938 1 0 decap_w0
xfeed_7937 1 0 decap_w0
xfeed_7936 1 0 decap_w0
xfeed_7935 1 0 decap_w0
xfeed_7934 1 0 decap_w0
xfeed_7933 1 0 decap_w0
xfeed_7932 1 0 decap_w0
xfeed_7931 1 0 decap_w0
xfeed_7930 1 0 decap_w0
xfeed_4159 1 0 decap_w0
xfeed_4158 1 0 decap_w0
xfeed_4157 1 0 decap_w0
xfeed_4156 1 0 decap_w0
xfeed_4155 1 0 decap_w0
xfeed_4154 1 0 decap_w0
xfeed_4153 1 0 decap_w0
xfeed_4152 1 0 decap_w0
xfeed_4151 1 0 decap_w0
xfeed_4150 1 0 decap_w0
xfeed_3629 1 0 decap_w0
xfeed_3628 1 0 decap_w0
xfeed_3627 1 0 decap_w0
xfeed_3626 1 0 decap_w0
xfeed_3625 1 0 decap_w0
xfeed_3624 1 0 decap_w0
xfeed_3623 1 0 decap_w0
xfeed_3622 1 0 decap_w0
xfeed_3621 1 0 decap_w0
xfeed_3620 1 0 decap_w0
xdiode_9 1 0 41 diode_w1
xdiode_8 1 0 41 diode_w1
xdiode_7 1 0 52 diode_w1
xdiode_6 1 0 63 diode_w1
xdiode_5 1 0 63 diode_w1
xdiode_4 1 0 63 diode_w1
xdiode_3 1 0 63 diode_w1
xdiode_2 1 0 63 diode_w1
xdiode_1 1 0 64 diode_w1
xdiode_0 1 0 64 diode_w1
xfeed_30989 1 0 decap_w0
xfeed_30988 1 0 decap_w0
xfeed_30987 1 0 decap_w0
xfeed_30986 1 0 decap_w0
xfeed_30985 1 0 decap_w0
xfeed_30984 1 0 decap_w0
xfeed_30983 1 0 decap_w0
xfeed_30982 1 0 decap_w0
xfeed_30981 1 0 decap_w0
xfeed_30980 1 0 decap_w0
xfeed_29909 1 0 decap_w0
xfeed_29908 1 0 decap_w0
xfeed_29907 1 0 decap_w0
xfeed_29906 1 0 decap_w0
xfeed_29905 1 0 decap_w0
xfeed_29904 1 0 decap_w0
xfeed_29903 1 0 decap_w0
xfeed_29902 1 0 decap_w0
xfeed_29901 1 0 decap_w0
xfeed_29900 1 0 decap_w0
xfeed_26129 1 0 decap_w0
xfeed_26128 1 0 decap_w0
xfeed_26127 1 0 decap_w0
xfeed_26126 1 0 decap_w0
xfeed_26125 1 0 decap_w0
xfeed_26124 1 0 decap_w0
xfeed_26123 1 0 decap_w0
xfeed_26122 1 0 decap_w0
xfeed_26121 1 0 decap_w0
xfeed_26120 1 0 decap_w0
xfeed_24989 1 0 decap_w0
xfeed_24988 1 0 decap_w0
xfeed_24987 1 0 decap_w0
xfeed_24986 1 0 decap_w0
xfeed_24985 1 0 decap_w0
xfeed_24984 1 0 decap_w0
xfeed_24983 1 0 decap_w0
xfeed_24982 1 0 decap_w0
xfeed_24981 1 0 decap_w0
xfeed_24980 1 0 decap_w0
xfeed_20679 1 0 decap_w0
xfeed_20678 1 0 decap_w0
xfeed_20677 1 0 decap_w0
xfeed_20676 1 0 decap_w0
xfeed_20675 1 0 decap_w0
xfeed_20674 1 0 decap_w0
xfeed_20673 1 0 decap_w0
xfeed_20672 1 0 decap_w0
xfeed_20671 1 0 decap_w0
xfeed_20670 1 0 decap_w0
xfeed_14678 1 0 decap_w0
xfeed_14677 1 0 decap_w0
xfeed_14676 1 0 decap_w0
xfeed_14675 1 0 decap_w0
xfeed_14674 1 0 decap_w0
xfeed_14673 1 0 decap_w0
xfeed_14672 1 0 decap_w0
xfeed_14671 1 0 decap_w0
xfeed_14670 1 0 decap_w0
xfeed_10369 1 0 decap_w0
xfeed_10368 1 0 decap_w0
xfeed_10367 1 0 decap_w0
xfeed_10366 1 0 decap_w0
xfeed_10365 1 0 decap_w0
xfeed_10364 1 0 decap_w0
xfeed_10363 1 0 decap_w0
xfeed_10362 1 0 decap_w0
xfeed_10361 1 0 decap_w0
xfeed_10360 1 0 decap_w0
xfeed_990 1 0 decap_w0
xfeed_991 1 0 decap_w0
xfeed_992 1 0 decap_w0
xfeed_993 1 0 decap_w0
xfeed_994 1 0 decap_w0
xfeed_995 1 0 decap_w0
xfeed_996 1 0 decap_w0
xfeed_997 1 0 decap_w0
xfeed_998 1 0 decap_w0
xfeed_999 1 0 decap_w0
xfeed_31609 1 0 decap_w0
xfeed_31608 1 0 decap_w0
xfeed_31607 1 0 decap_w0
xfeed_31606 1 0 decap_w0
xfeed_31605 1 0 decap_w0
xfeed_31604 1 0 decap_w0
xfeed_31603 1 0 decap_w0
xfeed_31602 1 0 decap_w0
xfeed_31601 1 0 decap_w0
xfeed_31600 1 0 decap_w0
xfeed_18989 1 0 decap_w0
xfeed_18988 1 0 decap_w0
xfeed_18987 1 0 decap_w0
xfeed_18986 1 0 decap_w0
xfeed_18985 1 0 decap_w0
xfeed_18984 1 0 decap_w0
xfeed_18983 1 0 decap_w0
xfeed_18982 1 0 decap_w0
xfeed_18981 1 0 decap_w0
xfeed_18980 1 0 decap_w0
xfeed_14679 1 0 decap_w0
xfeed_8479 1 0 decap_w0
xfeed_8478 1 0 decap_w0
xfeed_8477 1 0 decap_w0
xfeed_8476 1 0 decap_w0
xfeed_8475 1 0 decap_w0
xfeed_8474 1 0 decap_w0
xfeed_8473 1 0 decap_w0
xfeed_8472 1 0 decap_w0
xfeed_8471 1 0 decap_w0
xfeed_8470 1 0 decap_w0
xfeed_7949 1 0 decap_w0
xfeed_7948 1 0 decap_w0
xfeed_7947 1 0 decap_w0
xfeed_7946 1 0 decap_w0
xfeed_7945 1 0 decap_w0
xfeed_7944 1 0 decap_w0
xfeed_7943 1 0 decap_w0
xfeed_7942 1 0 decap_w0
xfeed_7941 1 0 decap_w0
xfeed_7940 1 0 decap_w0
xfeed_4169 1 0 decap_w0
xfeed_4168 1 0 decap_w0
xfeed_4167 1 0 decap_w0
xfeed_4166 1 0 decap_w0
xfeed_4165 1 0 decap_w0
xfeed_4164 1 0 decap_w0
xfeed_4163 1 0 decap_w0
xfeed_4162 1 0 decap_w0
xfeed_4161 1 0 decap_w0
xfeed_4160 1 0 decap_w0
xfeed_3639 1 0 decap_w0
xfeed_3638 1 0 decap_w0
xfeed_3637 1 0 decap_w0
xfeed_3636 1 0 decap_w0
xfeed_3635 1 0 decap_w0
xfeed_3634 1 0 decap_w0
xfeed_3633 1 0 decap_w0
xfeed_3632 1 0 decap_w0
xfeed_3631 1 0 decap_w0
xfeed_3630 1 0 decap_w0
xfeed_30999 1 0 decap_w0
xfeed_30998 1 0 decap_w0
xfeed_30997 1 0 decap_w0
xfeed_30996 1 0 decap_w0
xfeed_30995 1 0 decap_w0
xfeed_30994 1 0 decap_w0
xfeed_30993 1 0 decap_w0
xfeed_30992 1 0 decap_w0
xfeed_30991 1 0 decap_w0
xfeed_30990 1 0 decap_w0
xfeed_29919 1 0 decap_w0
xfeed_29918 1 0 decap_w0
xfeed_29917 1 0 decap_w0
xfeed_29916 1 0 decap_w0
xfeed_29915 1 0 decap_w0
xfeed_29914 1 0 decap_w0
xfeed_29913 1 0 decap_w0
xfeed_29912 1 0 decap_w0
xfeed_29911 1 0 decap_w0
xfeed_29910 1 0 decap_w0
xfeed_26139 1 0 decap_w0
xfeed_26138 1 0 decap_w0
xfeed_26137 1 0 decap_w0
xfeed_26136 1 0 decap_w0
xfeed_26135 1 0 decap_w0
xfeed_26134 1 0 decap_w0
xfeed_26133 1 0 decap_w0
xfeed_26132 1 0 decap_w0
xfeed_26131 1 0 decap_w0
xfeed_26130 1 0 decap_w0
xfeed_25609 1 0 decap_w0
xfeed_25608 1 0 decap_w0
xfeed_25607 1 0 decap_w0
xfeed_25606 1 0 decap_w0
xfeed_25605 1 0 decap_w0
xfeed_25604 1 0 decap_w0
xfeed_25603 1 0 decap_w0
xfeed_25602 1 0 decap_w0
xfeed_25601 1 0 decap_w0
xfeed_25600 1 0 decap_w0
xfeed_24999 1 0 decap_w0
xfeed_24998 1 0 decap_w0
xfeed_24997 1 0 decap_w0
xfeed_24996 1 0 decap_w0
xfeed_24995 1 0 decap_w0
xfeed_24994 1 0 decap_w0
xfeed_24993 1 0 tie
xfeed_24992 1 0 decap_w0
xfeed_24991 1 0 decap_w0
xfeed_24990 1 0 decap_w0
xfeed_20689 1 0 decap_w0
xfeed_20688 1 0 decap_w0
xfeed_20687 1 0 decap_w0
xfeed_20686 1 0 decap_w0
xfeed_20685 1 0 decap_w0
xfeed_20684 1 0 decap_w0
xfeed_20683 1 0 decap_w0
xfeed_20682 1 0 decap_w0
xfeed_20681 1 0 decap_w0
xfeed_20680 1 0 decap_w0
xfeed_19609 1 0 decap_w0
xfeed_19608 1 0 decap_w0
xfeed_19607 1 0 decap_w0
xfeed_19606 1 0 decap_w0
xfeed_19605 1 0 decap_w0
xfeed_19604 1 0 decap_w0
xfeed_19603 1 0 decap_w0
xfeed_19602 1 0 decap_w0
xfeed_19601 1 0 decap_w0
xfeed_19600 1 0 decap_w0
xfeed_14685 1 0 decap_w0
xfeed_14684 1 0 decap_w0
xfeed_14683 1 0 decap_w0
xfeed_14682 1 0 decap_w0
xfeed_14681 1 0 decap_w0
xfeed_14680 1 0 decap_w0
xfeed_10379 1 0 decap_w0
xfeed_10378 1 0 decap_w0
xfeed_10377 1 0 decap_w0
xfeed_10376 1 0 decap_w0
xfeed_10375 1 0 decap_w0
xfeed_10374 1 0 decap_w0
xfeed_10373 1 0 decap_w0
xfeed_10372 1 0 decap_w0
xfeed_10371 1 0 decap_w0
xfeed_10370 1 0 decap_w0
xfeed_31619 1 0 decap_w0
xfeed_31618 1 0 decap_w0
xfeed_31617 1 0 decap_w0
xfeed_31616 1 0 decap_w0
xfeed_31615 1 0 decap_w0
xfeed_31614 1 0 decap_w0
xfeed_31613 1 0 decap_w0
xfeed_31612 1 0 decap_w0
xfeed_31611 1 0 decap_w0
xfeed_31610 1 0 decap_w0
xfeed_18999 1 0 decap_w0
xfeed_18998 1 0 decap_w0
xfeed_18997 1 0 decap_w0
xfeed_18996 1 0 decap_w0
xfeed_18995 1 0 decap_w0
xfeed_18994 1 0 decap_w0
xfeed_18993 1 0 decap_w0
xfeed_18992 1 0 decap_w0
xfeed_18991 1 0 decap_w0
xfeed_18990 1 0 decap_w0
xfeed_14689 1 0 decap_w0
xfeed_14688 1 0 decap_w0
xfeed_14687 1 0 decap_w0
xfeed_14686 1 0 decap_w0
xfeed_8489 1 0 decap_w0
xfeed_8488 1 0 decap_w0
xfeed_8487 1 0 decap_w0
xfeed_8486 1 0 decap_w0
xfeed_8485 1 0 decap_w0
xfeed_8484 1 0 decap_w0
xfeed_8483 1 0 decap_w0
xfeed_8482 1 0 decap_w0
xfeed_8481 1 0 decap_w0
xfeed_8480 1 0 decap_w0
xfeed_7959 1 0 decap_w0
xfeed_7958 1 0 decap_w0
xfeed_7957 1 0 decap_w0
xfeed_7956 1 0 decap_w0
xfeed_7955 1 0 decap_w0
xfeed_7954 1 0 decap_w0
xfeed_7953 1 0 decap_w0
xfeed_7952 1 0 decap_w0
xfeed_7951 1 0 decap_w0
xfeed_7950 1 0 decap_w0
xfeed_4179 1 0 tie
xfeed_4178 1 0 decap_w0
xfeed_4177 1 0 decap_w0
xfeed_4176 1 0 decap_w0
xfeed_4175 1 0 decap_w0
xfeed_4174 1 0 decap_w0
xfeed_4173 1 0 decap_w0
xfeed_4172 1 0 decap_w0
xfeed_4171 1 0 decap_w0
xfeed_4170 1 0 decap_w0
xfeed_3649 1 0 decap_w0
xfeed_3648 1 0 decap_w0
xfeed_3647 1 0 decap_w0
xfeed_3646 1 0 decap_w0
xfeed_3645 1 0 decap_w0
xfeed_3644 1 0 decap_w0
xfeed_3643 1 0 decap_w0
xfeed_3642 1 0 decap_w0
xfeed_3641 1 0 decap_w0
xfeed_3640 1 0 decap_w0
xfeed_29929 1 0 decap_w0
xfeed_29928 1 0 decap_w0
xfeed_29927 1 0 decap_w0
xfeed_29926 1 0 decap_w0
xfeed_29925 1 0 decap_w0
xfeed_29924 1 0 decap_w0
xfeed_29923 1 0 decap_w0
xfeed_29922 1 0 decap_w0
xfeed_29921 1 0 decap_w0
xfeed_29920 1 0 decap_w0
xfeed_26149 1 0 decap_w0
xfeed_26148 1 0 decap_w0
xfeed_26147 1 0 decap_w0
xfeed_26146 1 0 decap_w0
xfeed_26145 1 0 decap_w0
xfeed_26144 1 0 decap_w0
xfeed_26143 1 0 decap_w0
xfeed_26142 1 0 decap_w0
xfeed_26141 1 0 decap_w0
xfeed_26140 1 0 decap_w0
xfeed_25619 1 0 decap_w0
xfeed_25618 1 0 decap_w0
xfeed_25617 1 0 decap_w0
xfeed_25616 1 0 decap_w0
xfeed_25615 1 0 decap_w0
xfeed_25614 1 0 decap_w0
xfeed_25613 1 0 decap_w0
xfeed_25612 1 0 decap_w0
xfeed_25611 1 0 decap_w0
xfeed_25610 1 0 decap_w0
xfeed_21309 1 0 decap_w0
xfeed_21308 1 0 decap_w0
xfeed_21307 1 0 decap_w0
xfeed_21306 1 0 decap_w0
xfeed_21305 1 0 decap_w0
xfeed_21304 1 0 decap_w0
xfeed_21303 1 0 decap_w0
xfeed_21302 1 0 decap_w0
xfeed_21301 1 0 decap_w0
xfeed_21300 1 0 decap_w0
xfeed_20699 1 0 decap_w0
xfeed_20698 1 0 decap_w0
xfeed_20697 1 0 decap_w0
xfeed_20696 1 0 decap_w0
xfeed_20695 1 0 decap_w0
xfeed_20694 1 0 decap_w0
xfeed_20693 1 0 decap_w0
xfeed_20692 1 0 decap_w0
xfeed_20691 1 0 decap_w0
xfeed_20690 1 0 decap_w0
xfeed_19619 1 0 decap_w0
xfeed_19618 1 0 decap_w0
xfeed_19617 1 0 decap_w0
xfeed_19616 1 0 decap_w0
xfeed_19615 1 0 decap_w0
xfeed_19614 1 0 decap_w0
xfeed_19613 1 0 decap_w0
xfeed_19612 1 0 decap_w0
xfeed_19611 1 0 decap_w0
xfeed_19610 1 0 decap_w0
xfeed_15309 1 0 decap_w0
xfeed_15308 1 0 decap_w0
xfeed_15307 1 0 decap_w0
xfeed_15306 1 0 decap_w0
xfeed_15305 1 0 decap_w0
xfeed_15304 1 0 decap_w0
xfeed_15303 1 0 decap_w0
xfeed_15302 1 0 decap_w0
xfeed_15301 1 0 decap_w0
xfeed_15300 1 0 decap_w0
xfeed_14692 1 0 decap_w0
xfeed_14691 1 0 decap_w0
xfeed_14690 1 0 decap_w0
xfeed_10389 1 0 decap_w0
xfeed_10388 1 0 decap_w0
xfeed_10387 1 0 decap_w0
xfeed_10386 1 0 decap_w0
xfeed_10385 1 0 decap_w0
xfeed_10384 1 0 decap_w0
xfeed_10383 1 0 decap_w0
xfeed_10382 1 0 decap_w0
xfeed_10381 1 0 decap_w0
xfeed_10380 1 0 decap_w0
xfeed_31626 1 0 decap_w0
xfeed_31625 1 0 decap_w0
xfeed_31624 1 0 decap_w0
xfeed_31623 1 0 decap_w0
xfeed_31622 1 0 decap_w0
xfeed_31621 1 0 decap_w0
xfeed_31620 1 0 decap_w0
xfeed_14699 1 0 decap_w0
xfeed_14698 1 0 decap_w0
xfeed_14697 1 0 decap_w0
xfeed_14696 1 0 decap_w0
xfeed_14695 1 0 decap_w0
xfeed_14694 1 0 decap_w0
xfeed_14693 1 0 decap_w0
xfeed_9109 1 0 decap_w0
xfeed_9108 1 0 decap_w0
xfeed_9107 1 0 decap_w0
xfeed_9106 1 0 decap_w0
xfeed_9105 1 0 decap_w0
xfeed_9104 1 0 decap_w0
xfeed_9103 1 0 decap_w0
xfeed_9102 1 0 decap_w0
xfeed_9101 1 0 decap_w0
xfeed_9100 1 0 decap_w0
xfeed_8499 1 0 decap_w0
xfeed_8498 1 0 decap_w0
xfeed_8497 1 0 decap_w0
xfeed_8496 1 0 decap_w0
xfeed_8495 1 0 decap_w0
xfeed_8494 1 0 decap_w0
xfeed_8493 1 0 decap_w0
xfeed_8492 1 0 decap_w0
xfeed_8491 1 0 decap_w0
xfeed_8490 1 0 decap_w0
xfeed_7969 1 0 decap_w0
xfeed_7968 1 0 decap_w0
xfeed_7967 1 0 decap_w0
xfeed_7966 1 0 decap_w0
xfeed_7965 1 0 decap_w0
xfeed_7964 1 0 decap_w0
xfeed_7963 1 0 decap_w0
xfeed_7962 1 0 decap_w0
xfeed_7961 1 0 decap_w0
xfeed_7960 1 0 decap_w0
xfeed_4189 1 0 decap_w0
xfeed_4188 1 0 decap_w0
xfeed_4187 1 0 decap_w0
xfeed_4186 1 0 decap_w0
xfeed_4185 1 0 decap_w0
xfeed_4184 1 0 decap_w0
xfeed_4183 1 0 decap_w0
xfeed_4182 1 0 decap_w0
xfeed_4181 1 0 decap_w0
xfeed_4180 1 0 decap_w0
xfeed_3659 1 0 decap_w0
xfeed_3658 1 0 decap_w0
xfeed_3657 1 0 decap_w0
xfeed_3656 1 0 decap_w0
xfeed_3655 1 0 decap_w0
xfeed_3654 1 0 decap_w0
xfeed_3653 1 0 decap_w0
xfeed_3652 1 0 decap_w0
xfeed_3651 1 0 decap_w0
xfeed_3650 1 0 decap_w0
xfeed_31629 1 0 decap_w0
xfeed_31628 1 0 decap_w0
xfeed_31627 1 0 decap_w0
xfeed_29939 1 0 decap_w0
xfeed_29938 1 0 decap_w0
xfeed_29937 1 0 decap_w0
xfeed_29936 1 0 decap_w0
xfeed_29935 1 0 decap_w0
xfeed_29934 1 0 decap_w0
xfeed_29933 1 0 decap_w0
xfeed_29932 1 0 decap_w0
xfeed_29931 1 0 decap_w0
xfeed_29930 1 0 decap_w0
xfeed_26159 1 0 decap_w0
xfeed_26158 1 0 decap_w0
xfeed_26157 1 0 decap_w0
xfeed_26156 1 0 decap_w0
xfeed_26155 1 0 decap_w0
xfeed_26154 1 0 decap_w0
xfeed_26153 1 0 decap_w0
xfeed_26152 1 0 decap_w0
xfeed_26151 1 0 decap_w0
xfeed_26150 1 0 decap_w0
xfeed_25629 1 0 decap_w0
xfeed_25628 1 0 decap_w0
xfeed_25627 1 0 decap_w0
xfeed_25626 1 0 decap_w0
xfeed_25625 1 0 decap_w0
xfeed_25624 1 0 decap_w0
xfeed_25623 1 0 decap_w0
xfeed_25622 1 0 decap_w0
xfeed_25621 1 0 decap_w0
xfeed_25620 1 0 decap_w0
xfeed_21319 1 0 decap_w0
xfeed_21318 1 0 decap_w0
xfeed_21317 1 0 decap_w0
xfeed_21316 1 0 decap_w0
xfeed_21315 1 0 decap_w0
xfeed_21314 1 0 decap_w0
xfeed_21313 1 0 decap_w0
xfeed_21312 1 0 decap_w0
xfeed_21311 1 0 decap_w0
xfeed_21310 1 0 decap_w0
xfeed_19629 1 0 decap_w0
xfeed_19628 1 0 decap_w0
xfeed_19627 1 0 decap_w0
xfeed_19626 1 0 decap_w0
xfeed_19625 1 0 decap_w0
xfeed_19624 1 0 decap_w0
xfeed_19623 1 0 decap_w0
xfeed_19622 1 0 decap_w0
xfeed_19621 1 0 decap_w0
xfeed_19620 1 0 decap_w0
xfeed_15319 1 0 decap_w0
xfeed_15318 1 0 decap_w0
xfeed_15317 1 0 decap_w0
xfeed_15316 1 0 decap_w0
xfeed_15315 1 0 decap_w0
xfeed_15314 1 0 decap_w0
xfeed_15313 1 0 decap_w0
xfeed_15312 1 0 decap_w0
xfeed_15311 1 0 decap_w0
xfeed_15310 1 0 decap_w0
xfeed_11009 1 0 decap_w0
xfeed_11008 1 0 decap_w0
xfeed_11007 1 0 decap_w0
xfeed_11006 1 0 decap_w0
xfeed_11005 1 0 decap_w0
xfeed_11004 1 0 decap_w0
xfeed_11003 1 0 decap_w0
xfeed_11002 1 0 decap_w0
xfeed_11001 1 0 decap_w0
xfeed_11000 1 0 decap_w0
xfeed_10399 1 0 decap_w0
xfeed_10398 1 0 decap_w0
xfeed_10397 1 0 decap_w0
xfeed_10396 1 0 decap_w0
xfeed_10395 1 0 decap_w0
xfeed_10394 1 0 decap_w0
xfeed_10393 1 0 decap_w0
xfeed_10392 1 0 decap_w0
xfeed_10391 1 0 decap_w0
xfeed_10390 1 0 decap_w0
xfeed_31633 1 0 decap_w0
xfeed_31632 1 0 decap_w0
xfeed_31631 1 0 decap_w0
xfeed_31630 1 0 decap_w0
xfeed_9119 1 0 decap_w0
xfeed_9118 1 0 decap_w0
xfeed_9117 1 0 decap_w0
xfeed_9116 1 0 decap_w0
xfeed_9115 1 0 decap_w0
xfeed_9114 1 0 decap_w0
xfeed_9113 1 0 decap_w0
xfeed_9112 1 0 decap_w0
xfeed_9111 1 0 decap_w0
xfeed_9110 1 0 decap_w0
xfeed_7977 1 0 decap_w0
xfeed_7976 1 0 decap_w0
xfeed_7975 1 0 decap_w0
xfeed_7974 1 0 decap_w0
xfeed_7973 1 0 decap_w0
xfeed_7972 1 0 decap_w0
xfeed_7971 1 0 tie
xfeed_7970 1 0 decap_w0
xfeed_4199 1 0 decap_w0
xfeed_4198 1 0 decap_w0
xfeed_4197 1 0 decap_w0
xfeed_4196 1 0 decap_w0
xfeed_4195 1 0 decap_w0
xfeed_4194 1 0 decap_w0
xfeed_4193 1 0 decap_w0
xfeed_4192 1 0 decap_w0
xfeed_4191 1 0 decap_w0
xfeed_4190 1 0 decap_w0
xfeed_3669 1 0 decap_w0
xfeed_3668 1 0 decap_w0
xfeed_3667 1 0 decap_w0
xfeed_3666 1 0 decap_w0
xfeed_3665 1 0 decap_w0
xfeed_3664 1 0 decap_w0
xfeed_3663 1 0 decap_w0
xfeed_3662 1 0 decap_w0
xfeed_3661 1 0 decap_w0
xfeed_3660 1 0 decap_w0
xfeed_31639 1 0 decap_w0
xfeed_31638 1 0 decap_w0
xfeed_31637 1 0 decap_w0
xfeed_31636 1 0 decap_w0
xfeed_31635 1 0 decap_w0
xfeed_31634 1 0 decap_w0
xfeed_29949 1 0 decap_w0
xfeed_29948 1 0 decap_w0
xfeed_29947 1 0 decap_w0
xfeed_29946 1 0 decap_w0
xfeed_29945 1 0 decap_w0
xfeed_29944 1 0 decap_w0
xfeed_29943 1 0 decap_w0
xfeed_29942 1 0 decap_w0
xfeed_29941 1 0 decap_w0
xfeed_29940 1 0 decap_w0
xfeed_26169 1 0 decap_w0
xfeed_26168 1 0 decap_w0
xfeed_26167 1 0 decap_w0
xfeed_26166 1 0 decap_w0
xfeed_26165 1 0 decap_w0
xfeed_26164 1 0 decap_w0
xfeed_26163 1 0 decap_w0
xfeed_26162 1 0 decap_w0
xfeed_26161 1 0 decap_w0
xfeed_26160 1 0 decap_w0
xfeed_25639 1 0 decap_w0
xfeed_25638 1 0 decap_w0
xfeed_25637 1 0 decap_w0
xfeed_25636 1 0 decap_w0
xfeed_25635 1 0 decap_w0
xfeed_25634 1 0 decap_w0
xfeed_25633 1 0 decap_w0
xfeed_25632 1 0 decap_w0
xfeed_25631 1 0 decap_w0
xfeed_25630 1 0 decap_w0
xfeed_21329 1 0 decap_w0
xfeed_21328 1 0 decap_w0
xfeed_21327 1 0 decap_w0
xfeed_21326 1 0 decap_w0
xfeed_21325 1 0 decap_w0
xfeed_21324 1 0 decap_w0
xfeed_21323 1 0 decap_w0
xfeed_21322 1 0 decap_w0
xfeed_21321 1 0 decap_w0
xfeed_21320 1 0 decap_w0
xfeed_19639 1 0 decap_w0
xfeed_19638 1 0 decap_w0
xfeed_19637 1 0 decap_w0
xfeed_19636 1 0 decap_w0
xfeed_19635 1 0 decap_w0
xfeed_19634 1 0 decap_w0
xfeed_19633 1 0 decap_w0
xfeed_19632 1 0 decap_w0
xfeed_19631 1 0 decap_w0
xfeed_19630 1 0 decap_w0
xfeed_15329 1 0 decap_w0
xfeed_15328 1 0 decap_w0
xfeed_15327 1 0 decap_w0
xfeed_15326 1 0 decap_w0
xfeed_15325 1 0 decap_w0
xfeed_15324 1 0 decap_w0
xfeed_15323 1 0 decap_w0
xfeed_15322 1 0 decap_w0
xfeed_15321 1 0 decap_w0
xfeed_15320 1 0 decap_w0
xfeed_11019 1 0 decap_w0
xfeed_11018 1 0 decap_w0
xfeed_11017 1 0 decap_w0
xfeed_11016 1 0 decap_w0
xfeed_11015 1 0 decap_w0
xfeed_11014 1 0 decap_w0
xfeed_11013 1 0 decap_w0
xfeed_11012 1 0 decap_w0
xfeed_11011 1 0 decap_w0
xfeed_11010 1 0 decap_w0
xfeed_7979 1 0 decap_w0
xfeed_7978 1 0 decap_w0
xfeed_31640 1 0 decap_w0
xfeed_9129 1 0 decap_w0
xfeed_9128 1 0 decap_w0
xfeed_9127 1 0 decap_w0
xfeed_9126 1 0 decap_w0
xfeed_9125 1 0 decap_w0
xfeed_9124 1 0 decap_w0
xfeed_9123 1 0 decap_w0
xfeed_9122 1 0 decap_w0
xfeed_9121 1 0 decap_w0
xfeed_9120 1 0 decap_w0
xfeed_7984 1 0 decap_w0
xfeed_7983 1 0 decap_w0
xfeed_7982 1 0 decap_w0
xfeed_7981 1 0 decap_w0
xfeed_7980 1 0 decap_w0
xfeed_3679 1 0 decap_w0
xfeed_3678 1 0 decap_w0
xfeed_3677 1 0 decap_w0
xfeed_3676 1 0 decap_w0
xfeed_3675 1 0 decap_w0
xfeed_3674 1 0 decap_w0
xfeed_3673 1 0 decap_w0
xfeed_3672 1 0 decap_w0
xfeed_3671 1 0 decap_w0
xfeed_3670 1 0 decap_w0
xfeed_31649 1 0 decap_w0
xfeed_31648 1 0 decap_w0
xfeed_31647 1 0 decap_w0
xfeed_31646 1 0 decap_w0
xfeed_31645 1 0 decap_w0
xfeed_31644 1 0 decap_w0
xfeed_31643 1 0 decap_w0
xfeed_31642 1 0 decap_w0
xfeed_31641 1 0 decap_w0
xfeed_29959 1 0 decap_w0
xfeed_29958 1 0 decap_w0
xfeed_29957 1 0 decap_w0
xfeed_29956 1 0 decap_w0
xfeed_29955 1 0 decap_w0
xfeed_29954 1 0 decap_w0
xfeed_29953 1 0 decap_w0
xfeed_29952 1 0 decap_w0
xfeed_29951 1 0 decap_w0
xfeed_29950 1 0 decap_w0
xfeed_26179 1 0 decap_w0
xfeed_26178 1 0 decap_w0
xfeed_26177 1 0 decap_w0
xfeed_26176 1 0 decap_w0
xfeed_26175 1 0 decap_w0
xfeed_26174 1 0 decap_w0
xfeed_26173 1 0 decap_w0
xfeed_26172 1 0 decap_w0
xfeed_26171 1 0 decap_w0
xfeed_26170 1 0 decap_w0
xfeed_25649 1 0 decap_w0
xfeed_25648 1 0 decap_w0
xfeed_25647 1 0 decap_w0
xfeed_25646 1 0 decap_w0
xfeed_25645 1 0 decap_w0
xfeed_25644 1 0 decap_w0
xfeed_25643 1 0 decap_w0
xfeed_25642 1 0 decap_w0
xfeed_25641 1 0 decap_w0
xfeed_25640 1 0 decap_w0
xfeed_21339 1 0 decap_w0
xfeed_21338 1 0 decap_w0
xfeed_21337 1 0 decap_w0
xfeed_21336 1 0 decap_w0
xfeed_21335 1 0 decap_w0
xfeed_21334 1 0 decap_w0
xfeed_21333 1 0 decap_w0
xfeed_21332 1 0 decap_w0
xfeed_21331 1 0 decap_w0
xfeed_21330 1 0 decap_w0
xfeed_20809 1 0 decap_w0
xfeed_20808 1 0 decap_w0
xfeed_20807 1 0 decap_w0
xfeed_20806 1 0 decap_w0
xfeed_20805 1 0 decap_w0
xfeed_20804 1 0 decap_w0
xfeed_20803 1 0 decap_w0
xfeed_20802 1 0 decap_w0
xfeed_20801 1 0 decap_w0
xfeed_20800 1 0 decap_w0
xfeed_19649 1 0 decap_w0
xfeed_19648 1 0 decap_w0
xfeed_19647 1 0 decap_w0
xfeed_19646 1 0 decap_w0
xfeed_19645 1 0 decap_w0
xfeed_19644 1 0 decap_w0
xfeed_19643 1 0 decap_w0
xfeed_19642 1 0 decap_w0
xfeed_19641 1 0 decap_w0
xfeed_19640 1 0 decap_w0
xfeed_15339 1 0 decap_w0
xfeed_15338 1 0 decap_w0
xfeed_15337 1 0 decap_w0
xfeed_15336 1 0 decap_w0
xfeed_15335 1 0 decap_w0
xfeed_15334 1 0 decap_w0
xfeed_15333 1 0 decap_w0
xfeed_15332 1 0 decap_w0
xfeed_15331 1 0 decap_w0
xfeed_15330 1 0 decap_w0
xfeed_14809 1 0 decap_w0
xfeed_14808 1 0 decap_w0
xfeed_14807 1 0 decap_w0
xfeed_14806 1 0 decap_w0
xfeed_14805 1 0 decap_w0
xfeed_14804 1 0 decap_w0
xfeed_14803 1 0 decap_w0
xfeed_14802 1 0 decap_w0
xfeed_14801 1 0 decap_w0
xfeed_14800 1 0 decap_w0
xfeed_11029 1 0 decap_w0
xfeed_11028 1 0 decap_w0
xfeed_11027 1 0 decap_w0
xfeed_11026 1 0 decap_w0
xfeed_11025 1 0 decap_w0
xfeed_11024 1 0 decap_w0
xfeed_11023 1 0 decap_w0
xfeed_11022 1 0 decap_w0
xfeed_11021 1 0 decap_w0
xfeed_11020 1 0 decap_w0
xfeed_7989 1 0 decap_w0
xfeed_7988 1 0 decap_w0
xfeed_7987 1 0 decap_w0
xfeed_7986 1 0 decap_w0
xfeed_7985 1 0 decap_w0
xfeed_9139 1 0 decap_w0
xfeed_9138 1 0 decap_w0
xfeed_9137 1 0 decap_w0
xfeed_9136 1 0 decap_w0
xfeed_9135 1 0 decap_w0
xfeed_9134 1 0 decap_w0
xfeed_9133 1 0 decap_w0
xfeed_9132 1 0 decap_w0
xfeed_9131 1 0 decap_w0
xfeed_9130 1 0 decap_w0
xfeed_8609 1 0 decap_w0
xfeed_8608 1 0 decap_w0
xfeed_8607 1 0 decap_w0
xfeed_8606 1 0 decap_w0
xfeed_8605 1 0 decap_w0
xfeed_8604 1 0 decap_w0
xfeed_8603 1 0 decap_w0
xfeed_8602 1 0 decap_w0
xfeed_8601 1 0 decap_w0
xfeed_8600 1 0 decap_w0
xfeed_7991 1 0 decap_w0
xfeed_7990 1 0 decap_w0
xfeed_3689 1 0 decap_w0
xfeed_3688 1 0 decap_w0
xfeed_3687 1 0 decap_w0
xfeed_3686 1 0 decap_w0
xfeed_3685 1 0 decap_w0
xfeed_3684 1 0 decap_w0
xfeed_3683 1 0 decap_w0
xfeed_3682 1 0 decap_w0
xfeed_3681 1 0 decap_w0
xfeed_3680 1 0 decap_w0
xfeed_31659 1 0 decap_w0
xfeed_31658 1 0 decap_w0
xfeed_31657 1 0 decap_w0
xfeed_31656 1 0 decap_w0
xfeed_31655 1 0 decap_w0
xfeed_31654 1 0 decap_w0
xfeed_31653 1 0 decap_w0
xfeed_31652 1 0 decap_w0
xfeed_31651 1 0 decap_w0
xfeed_31650 1 0 decap_w0
xfeed_29969 1 0 decap_w0
xfeed_29968 1 0 decap_w0
xfeed_29967 1 0 decap_w0
xfeed_29966 1 0 decap_w0
xfeed_29965 1 0 decap_w0
xfeed_29964 1 0 decap_w0
xfeed_29963 1 0 decap_w0
xfeed_29962 1 0 decap_w0
xfeed_29961 1 0 decap_w0
xfeed_29960 1 0 decap_w0
xfeed_26189 1 0 decap_w0
xfeed_26188 1 0 decap_w0
xfeed_26187 1 0 decap_w0
xfeed_26186 1 0 decap_w0
xfeed_26185 1 0 decap_w0
xfeed_26184 1 0 decap_w0
xfeed_26183 1 0 decap_w0
xfeed_26182 1 0 decap_w0
xfeed_26181 1 0 decap_w0
xfeed_26180 1 0 decap_w0
xfeed_25659 1 0 decap_w0
xfeed_25658 1 0 decap_w0
xfeed_25657 1 0 decap_w0
xfeed_25656 1 0 decap_w0
xfeed_25655 1 0 decap_w0
xfeed_25654 1 0 decap_w0
xfeed_25653 1 0 decap_w0
xfeed_25652 1 0 decap_w0
xfeed_25651 1 0 decap_w0
xfeed_25650 1 0 decap_w0
xfeed_21349 1 0 decap_w0
xfeed_21348 1 0 decap_w0
xfeed_21347 1 0 decap_w0
xfeed_21346 1 0 decap_w0
xfeed_21345 1 0 decap_w0
xfeed_21344 1 0 decap_w0
xfeed_21343 1 0 decap_w0
xfeed_21342 1 0 decap_w0
xfeed_21341 1 0 decap_w0
xfeed_21340 1 0 decap_w0
xfeed_20819 1 0 decap_w0
xfeed_20818 1 0 decap_w0
xfeed_20817 1 0 decap_w0
xfeed_20816 1 0 decap_w0
xfeed_20815 1 0 decap_w0
xfeed_20814 1 0 decap_w0
xfeed_20813 1 0 decap_w0
xfeed_20812 1 0 decap_w0
xfeed_20811 1 0 decap_w0
xfeed_20810 1 0 decap_w0
xfeed_19657 1 0 decap_w0
xfeed_19656 1 0 decap_w0
xfeed_19655 1 0 decap_w0
xfeed_19654 1 0 decap_w0
xfeed_19653 1 0 decap_w0
xfeed_19652 1 0 decap_w0
xfeed_19651 1 0 decap_w0
xfeed_19650 1 0 decap_w0
xfeed_15349 1 0 decap_w0
xfeed_15348 1 0 decap_w0
xfeed_15347 1 0 decap_w0
xfeed_15346 1 0 decap_w0
xfeed_15345 1 0 decap_w0
xfeed_15344 1 0 decap_w0
xfeed_15343 1 0 decap_w0
xfeed_15342 1 0 decap_w0
xfeed_15341 1 0 decap_w0
xfeed_15340 1 0 decap_w0
xfeed_14818 1 0 decap_w0
xfeed_14817 1 0 decap_w0
xfeed_14816 1 0 decap_w0
xfeed_14815 1 0 decap_w0
xfeed_14814 1 0 decap_w0
xfeed_14813 1 0 decap_w0
xfeed_14812 1 0 decap_w0
xfeed_14811 1 0 decap_w0
xfeed_14810 1 0 decap_w0
xfeed_11039 1 0 decap_w0
xfeed_11038 1 0 decap_w0
xfeed_11037 1 0 decap_w0
xfeed_11036 1 0 decap_w0
xfeed_11035 1 0 decap_w0
xfeed_11034 1 0 decap_w0
xfeed_11033 1 0 decap_w0
xfeed_11032 1 0 decap_w0
xfeed_11031 1 0 decap_w0
xfeed_11030 1 0 decap_w0
xfeed_10509 1 0 decap_w0
xfeed_10508 1 0 decap_w0
xfeed_10507 1 0 decap_w0
xfeed_10506 1 0 decap_w0
xfeed_10505 1 0 decap_w0
xfeed_10504 1 0 decap_w0
xfeed_10503 1 0 decap_w0
xfeed_10502 1 0 decap_w0
xfeed_10501 1 0 decap_w0
xfeed_10500 1 0 decap_w0
xfeed_7999 1 0 decap_w0
xfeed_7998 1 0 decap_w0
xfeed_7997 1 0 decap_w0
xfeed_7996 1 0 decap_w0
xfeed_7995 1 0 decap_w0
xfeed_7994 1 0 decap_w0
xfeed_7993 1 0 decap_w0
xfeed_7992 1 0 decap_w0
xfeed_19659 1 0 decap_w0
xfeed_19658 1 0 decap_w0
xfeed_14819 1 0 decap_w0
xfeed_9149 1 0 decap_w0
xfeed_9148 1 0 decap_w0
xfeed_9147 1 0 decap_w0
xfeed_9146 1 0 decap_w0
xfeed_9145 1 0 decap_w0
xfeed_9144 1 0 decap_w0
xfeed_9143 1 0 decap_w0
xfeed_9142 1 0 decap_w0
xfeed_9141 1 0 decap_w0
xfeed_9140 1 0 decap_w0
xfeed_8619 1 0 decap_w0
xfeed_8618 1 0 decap_w0
xfeed_8617 1 0 decap_w0
xfeed_8616 1 0 decap_w0
xfeed_8615 1 0 decap_w0
xfeed_8614 1 0 decap_w0
xfeed_8613 1 0 decap_w0
xfeed_8612 1 0 decap_w0
xfeed_8611 1 0 decap_w0
xfeed_8610 1 0 decap_w0
xfeed_4309 1 0 decap_w0
xfeed_4308 1 0 decap_w0
xfeed_4307 1 0 decap_w0
xfeed_4306 1 0 decap_w0
xfeed_4305 1 0 decap_w0
xfeed_4304 1 0 decap_w0
xfeed_4303 1 0 decap_w0
xfeed_4302 1 0 decap_w0
xfeed_4301 1 0 decap_w0
xfeed_4300 1 0 decap_w0
xfeed_3698 1 0 decap_w0
xfeed_3697 1 0 decap_w0
xfeed_3696 1 0 decap_w0
xfeed_3695 1 0 decap_w0
xfeed_3694 1 0 decap_w0
xfeed_3693 1 0 decap_w0
xfeed_3692 1 0 decap_w0
xfeed_3691 1 0 decap_w0
xfeed_3690 1 0 decap_w0
xsubckt_40_inv_x0 1 0 182 14 inv_x0
xfeed_31669 1 0 decap_w0
xfeed_31668 1 0 decap_w0
xfeed_31667 1 0 decap_w0
xfeed_31666 1 0 decap_w0
xfeed_31665 1 0 decap_w0
xfeed_31664 1 0 decap_w0
xfeed_31663 1 0 decap_w0
xfeed_31662 1 0 decap_w0
xfeed_31661 1 0 decap_w0
xfeed_31660 1 0 decap_w0
xfeed_29979 1 0 decap_w0
xfeed_29978 1 0 decap_w0
xfeed_29977 1 0 decap_w0
xfeed_29976 1 0 decap_w0
xfeed_29975 1 0 decap_w0
xfeed_29974 1 0 decap_w0
xfeed_29973 1 0 decap_w0
xfeed_29972 1 0 decap_w0
xfeed_29971 1 0 decap_w0
xfeed_29970 1 0 decap_w0
xfeed_26199 1 0 decap_w0
xfeed_26198 1 0 decap_w0
xfeed_26197 1 0 decap_w0
xfeed_26196 1 0 decap_w0
xfeed_26195 1 0 decap_w0
xfeed_26194 1 0 decap_w0
xfeed_26193 1 0 decap_w0
xfeed_26192 1 0 decap_w0
xfeed_26191 1 0 decap_w0
xfeed_26190 1 0 decap_w0
xfeed_25669 1 0 decap_w0
xfeed_25668 1 0 decap_w0
xfeed_25667 1 0 decap_w0
xfeed_25666 1 0 decap_w0
xfeed_25665 1 0 decap_w0
xfeed_25664 1 0 decap_w0
xfeed_25663 1 0 decap_w0
xfeed_25662 1 0 decap_w0
xfeed_25661 1 0 decap_w0
xfeed_25660 1 0 decap_w0
xfeed_21359 1 0 decap_w0
xfeed_21358 1 0 decap_w0
xfeed_21357 1 0 decap_w0
xfeed_21356 1 0 decap_w0
xfeed_21355 1 0 decap_w0
xfeed_21354 1 0 decap_w0
xfeed_21353 1 0 decap_w0
xfeed_21352 1 0 decap_w0
xfeed_21351 1 0 decap_w0
xfeed_21350 1 0 decap_w0
xfeed_20829 1 0 decap_w0
xfeed_20828 1 0 decap_w0
xfeed_20827 1 0 decap_w0
xfeed_20826 1 0 decap_w0
xfeed_20825 1 0 decap_w0
xfeed_20824 1 0 decap_w0
xfeed_20823 1 0 decap_w0
xfeed_20822 1 0 decap_w0
xfeed_20821 1 0 decap_w0
xfeed_20820 1 0 decap_w0
xfeed_19664 1 0 decap_w0
xfeed_19663 1 0 decap_w0
xfeed_19662 1 0 decap_w0
xfeed_19661 1 0 decap_w0
xfeed_19660 1 0 decap_w0
xfeed_15359 1 0 decap_w0
xfeed_15358 1 0 decap_w0
xfeed_15357 1 0 decap_w0
xfeed_15356 1 0 decap_w0
xfeed_15355 1 0 decap_w0
xfeed_15354 1 0 decap_w0
xfeed_15353 1 0 decap_w0
xfeed_15352 1 0 decap_w0
xfeed_15351 1 0 decap_w0
xfeed_15350 1 0 decap_w0
xfeed_14825 1 0 decap_w0
xfeed_14824 1 0 decap_w0
xfeed_14823 1 0 decap_w0
xfeed_14822 1 0 decap_w0
xfeed_14821 1 0 decap_w0
xfeed_14820 1 0 decap_w0
xfeed_11049 1 0 decap_w0
xfeed_11048 1 0 decap_w0
xfeed_11047 1 0 decap_w0
xfeed_11046 1 0 decap_w0
xfeed_11045 1 0 decap_w0
xfeed_11044 1 0 decap_w0
xfeed_11043 1 0 decap_w0
xfeed_11042 1 0 decap_w0
xfeed_11041 1 0 decap_w0
xfeed_11040 1 0 decap_w0
xfeed_10519 1 0 decap_w0
xfeed_10518 1 0 decap_w0
xfeed_10517 1 0 decap_w0
xfeed_10516 1 0 decap_w0
xfeed_10515 1 0 decap_w0
xfeed_10514 1 0 decap_w0
xfeed_10513 1 0 decap_w0
xfeed_10512 1 0 decap_w0
xfeed_10511 1 0 tie
xfeed_10510 1 0 decap_w0
xfeed_3699 1 0 decap_w0
xsubckt_46_inv_x0 1 0 178 32 inv_x0
xfeed_19669 1 0 decap_w0
xfeed_19668 1 0 decap_w0
xfeed_19667 1 0 decap_w0
xfeed_19666 1 0 decap_w0
xfeed_19665 1 0 decap_w0
xfeed_14829 1 0 decap_w0
xfeed_14828 1 0 decap_w0
xfeed_14827 1 0 decap_w0
xfeed_14826 1 0 decap_w0
xfeed_9159 1 0 decap_w0
xfeed_9158 1 0 decap_w0
xfeed_9157 1 0 decap_w0
xfeed_9156 1 0 decap_w0
xfeed_9155 1 0 decap_w0
xfeed_9154 1 0 decap_w0
xfeed_9153 1 0 decap_w0
xfeed_9152 1 0 decap_w0
xfeed_9151 1 0 decap_w0
xfeed_9150 1 0 decap_w0
xfeed_8629 1 0 decap_w0
xfeed_8628 1 0 decap_w0
xfeed_8627 1 0 decap_w0
xfeed_8626 1 0 decap_w0
xfeed_8625 1 0 decap_w0
xfeed_8624 1 0 decap_w0
xfeed_8623 1 0 decap_w0
xfeed_8622 1 0 decap_w0
xfeed_8621 1 0 decap_w0
xfeed_8620 1 0 decap_w0
xfeed_4319 1 0 decap_w0
xfeed_4318 1 0 decap_w0
xfeed_4317 1 0 decap_w0
xfeed_4316 1 0 decap_w0
xfeed_4315 1 0 decap_w0
xfeed_4314 1 0 decap_w0
xfeed_4313 1 0 decap_w0
xfeed_4312 1 0 decap_w0
xfeed_4311 1 0 decap_w0
xfeed_4310 1 0 decap_w0
xfeed_31679 1 0 decap_w0
xfeed_31678 1 0 decap_w0
xfeed_31677 1 0 decap_w0
xfeed_31676 1 0 decap_w0
xfeed_31675 1 0 decap_w0
xfeed_31674 1 0 decap_w0
xfeed_31673 1 0 decap_w0
xfeed_31672 1 0 decap_w0
xfeed_31671 1 0 decap_w0
xfeed_31670 1 0 decap_w0
xfeed_29989 1 0 decap_w0
xfeed_29988 1 0 decap_w0
xfeed_29987 1 0 decap_w0
xfeed_29986 1 0 decap_w0
xfeed_29985 1 0 decap_w0
xfeed_29984 1 0 decap_w0
xfeed_29983 1 0 decap_w0
xfeed_29982 1 0 decap_w0
xfeed_29981 1 0 decap_w0
xfeed_29980 1 0 decap_w0
xfeed_25679 1 0 decap_w0
xfeed_25678 1 0 decap_w0
xfeed_25677 1 0 decap_w0
xfeed_25676 1 0 decap_w0
xfeed_25675 1 0 decap_w0
xfeed_25674 1 0 decap_w0
xfeed_25673 1 0 decap_w0
xfeed_25672 1 0 decap_w0
xfeed_25671 1 0 decap_w0
xfeed_25670 1 0 decap_w0
xfeed_21369 1 0 decap_w0
xfeed_21368 1 0 decap_w0
xfeed_21367 1 0 decap_w0
xfeed_21366 1 0 decap_w0
xfeed_21365 1 0 decap_w0
xfeed_21364 1 0 decap_w0
xfeed_21363 1 0 decap_w0
xfeed_21362 1 0 decap_w0
xfeed_21361 1 0 decap_w0
xfeed_21360 1 0 decap_w0
xfeed_20839 1 0 decap_w0
xfeed_20838 1 0 decap_w0
xfeed_20837 1 0 decap_w0
xfeed_20836 1 0 decap_w0
xfeed_20835 1 0 decap_w0
xfeed_20834 1 0 decap_w0
xfeed_20833 1 0 decap_w0
xfeed_20832 1 0 decap_w0
xfeed_20831 1 0 decap_w0
xfeed_20830 1 0 decap_w0
xfeed_19671 1 0 decap_w0
xfeed_19670 1 0 decap_w0
xfeed_15369 1 0 decap_w0
xfeed_15368 1 0 decap_w0
xfeed_15367 1 0 decap_w0
xfeed_15366 1 0 decap_w0
xfeed_15365 1 0 decap_w0
xfeed_15364 1 0 decap_w0
xfeed_15363 1 0 decap_w0
xfeed_15362 1 0 decap_w0
xfeed_15361 1 0 decap_w0
xfeed_15360 1 0 decap_w0
xfeed_14832 1 0 decap_w0
xfeed_14831 1 0 decap_w0
xfeed_14830 1 0 decap_w0
xfeed_11059 1 0 decap_w0
xfeed_11058 1 0 decap_w0
xfeed_11057 1 0 decap_w0
xfeed_11056 1 0 decap_w0
xfeed_11055 1 0 decap_w0
xfeed_11054 1 0 decap_w0
xfeed_11053 1 0 decap_w0
xfeed_11052 1 0 decap_w0
xfeed_11051 1 0 decap_w0
xfeed_11050 1 0 decap_w0
xfeed_10529 1 0 decap_w0
xfeed_10528 1 0 decap_w0
xfeed_10527 1 0 decap_w0
xfeed_10526 1 0 decap_w0
xfeed_10525 1 0 decap_w0
xfeed_10524 1 0 decap_w0
xfeed_10523 1 0 decap_w0
xfeed_10522 1 0 decap_w0
xfeed_10521 1 0 decap_w0
xfeed_10520 1 0 decap_w0
xfeed_19679 1 0 decap_w0
xfeed_19678 1 0 decap_w0
xfeed_19677 1 0 decap_w0
xfeed_19676 1 0 decap_w0
xfeed_19675 1 0 decap_w0
xfeed_19674 1 0 decap_w0
xfeed_19673 1 0 decap_w0
xfeed_19672 1 0 decap_w0
xfeed_14839 1 0 decap_w0
xfeed_14838 1 0 decap_w0
xfeed_14837 1 0 decap_w0
xfeed_14836 1 0 decap_w0
xfeed_14835 1 0 decap_w0
xfeed_14834 1 0 decap_w0
xfeed_14833 1 0 decap_w0
xfeed_9169 1 0 decap_w0
xfeed_9168 1 0 decap_w0
xfeed_9167 1 0 decap_w0
xfeed_9166 1 0 decap_w0
xfeed_9165 1 0 decap_w0
xfeed_9164 1 0 decap_w0
xfeed_9163 1 0 decap_w0
xfeed_9162 1 0 decap_w0
xfeed_9161 1 0 decap_w0
xfeed_9160 1 0 decap_w0
xfeed_8639 1 0 decap_w0
xfeed_8638 1 0 decap_w0
xfeed_8637 1 0 decap_w0
xfeed_8636 1 0 decap_w0
xfeed_8635 1 0 decap_w0
xfeed_8634 1 0 decap_w0
xfeed_8633 1 0 decap_w0
xfeed_8632 1 0 decap_w0
xfeed_8631 1 0 decap_w0
xfeed_8630 1 0 decap_w0
xfeed_4329 1 0 decap_w0
xfeed_4328 1 0 decap_w0
xfeed_4327 1 0 decap_w0
xfeed_4326 1 0 decap_w0
xfeed_4325 1 0 decap_w0
xfeed_4324 1 0 decap_w0
xfeed_4323 1 0 decap_w0
xfeed_4322 1 0 decap_w0
xfeed_4321 1 0 tie
xfeed_4320 1 0 decap_w0
xfeed_31689 1 0 decap_w0
xfeed_31688 1 0 decap_w0
xfeed_31687 1 0 decap_w0
xfeed_31686 1 0 decap_w0
xfeed_31685 1 0 decap_w0
xfeed_31684 1 0 decap_w0
xfeed_31683 1 0 decap_w0
xfeed_31682 1 0 decap_w0
xfeed_31681 1 0 decap_w0
xfeed_31680 1 0 decap_w0
xfeed_29999 1 0 decap_w0
xfeed_29998 1 0 decap_w0
xfeed_29997 1 0 decap_w0
xfeed_29996 1 0 decap_w0
xfeed_29995 1 0 decap_w0
xfeed_29994 1 0 decap_w0
xfeed_29993 1 0 decap_w0
xfeed_29992 1 0 decap_w0
xfeed_29991 1 0 decap_w0
xfeed_29990 1 0 decap_w0
xfeed_25689 1 0 decap_w0
xfeed_25688 1 0 decap_w0
xfeed_25687 1 0 decap_w0
xfeed_25686 1 0 decap_w0
xfeed_25685 1 0 decap_w0
xfeed_25684 1 0 decap_w0
xfeed_25683 1 0 decap_w0
xfeed_25682 1 0 decap_w0
xfeed_25681 1 0 decap_w0
xfeed_25680 1 0 decap_w0
xfeed_21379 1 0 decap_w0
xfeed_21378 1 0 decap_w0
xfeed_21377 1 0 decap_w0
xfeed_21376 1 0 decap_w0
xfeed_21375 1 0 decap_w0
xfeed_21374 1 0 decap_w0
xfeed_21373 1 0 decap_w0
xfeed_21372 1 0 decap_w0
xfeed_21371 1 0 decap_w0
xfeed_21370 1 0 decap_w0
xfeed_20849 1 0 decap_w0
xfeed_20848 1 0 decap_w0
xfeed_20847 1 0 decap_w0
xfeed_20846 1 0 decap_w0
xfeed_20845 1 0 decap_w0
xfeed_20844 1 0 decap_w0
xfeed_20843 1 0 decap_w0
xfeed_20842 1 0 decap_w0
xfeed_20841 1 0 decap_w0
xfeed_20840 1 0 decap_w0
xfeed_15378 1 0 decap_w0
xfeed_15377 1 0 decap_w0
xfeed_15376 1 0 decap_w0
xfeed_15375 1 0 decap_w0
xfeed_15374 1 0 decap_w0
xfeed_15373 1 0 decap_w0
xfeed_15372 1 0 decap_w0
xfeed_15371 1 0 decap_w0
xfeed_15370 1 0 decap_w0
xfeed_11069 1 0 decap_w0
xfeed_11068 1 0 decap_w0
xfeed_11067 1 0 decap_w0
xfeed_11066 1 0 decap_w0
xfeed_11065 1 0 decap_w0
xfeed_11064 1 0 decap_w0
xfeed_11063 1 0 decap_w0
xfeed_11062 1 0 decap_w0
xfeed_11061 1 0 decap_w0
xfeed_11060 1 0 decap_w0
xfeed_10539 1 0 decap_w0
xfeed_10538 1 0 decap_w0
xfeed_10537 1 0 decap_w0
xfeed_10536 1 0 decap_w0
xfeed_10535 1 0 decap_w0
xfeed_10534 1 0 decap_w0
xfeed_10533 1 0 decap_w0
xfeed_10532 1 0 decap_w0
xfeed_10531 1 0 decap_w0
xfeed_10530 1 0 decap_w0
xfeed_19689 1 0 decap_w0
xfeed_19688 1 0 decap_w0
xfeed_19687 1 0 decap_w0
xfeed_19686 1 0 decap_w0
xfeed_19685 1 0 decap_w0
xfeed_19684 1 0 decap_w0
xfeed_19683 1 0 decap_w0
xfeed_19682 1 0 decap_w0
xfeed_19681 1 0 decap_w0
xfeed_19680 1 0 decap_w0
xfeed_15379 1 0 decap_w0
xfeed_14849 1 0 decap_w0
xfeed_14848 1 0 decap_w0
xfeed_14847 1 0 decap_w0
xfeed_14846 1 0 decap_w0
xfeed_14845 1 0 decap_w0
xfeed_14844 1 0 decap_w0
xfeed_14843 1 0 decap_w0
xfeed_14842 1 0 decap_w0
xfeed_14841 1 0 decap_w0
xfeed_14840 1 0 decap_w0
xfeed_9179 1 0 decap_w0
xfeed_9178 1 0 decap_w0
xfeed_9177 1 0 decap_w0
xfeed_9176 1 0 decap_w0
xfeed_9175 1 0 decap_w0
xfeed_9174 1 0 decap_w0
xfeed_9173 1 0 decap_w0
xfeed_9172 1 0 decap_w0
xfeed_9171 1 0 decap_w0
xfeed_9170 1 0 decap_w0
xfeed_8649 1 0 decap_w0
xfeed_8648 1 0 decap_w0
xfeed_8647 1 0 decap_w0
xfeed_8646 1 0 decap_w0
xfeed_8645 1 0 decap_w0
xfeed_8644 1 0 decap_w0
xfeed_8643 1 0 decap_w0
xfeed_8642 1 0 decap_w0
xfeed_8641 1 0 decap_w0
xfeed_8640 1 0 decap_w0
xfeed_4339 1 0 decap_w0
xfeed_4338 1 0 decap_w0
xfeed_4337 1 0 decap_w0
xfeed_4336 1 0 decap_w0
xfeed_4335 1 0 decap_w0
xfeed_4334 1 0 decap_w0
xfeed_4333 1 0 decap_w0
xfeed_4332 1 0 decap_w0
xfeed_4331 1 0 decap_w0
xfeed_4330 1 0 decap_w0
xfeed_3809 1 0 decap_w0
xfeed_3808 1 0 decap_w0
xfeed_3807 1 0 decap_w0
xfeed_3806 1 0 decap_w0
xfeed_3805 1 0 decap_w0
xfeed_3804 1 0 decap_w0
xfeed_3803 1 0 decap_w0
xfeed_3802 1 0 decap_w0
xfeed_3801 1 0 decap_w0
xfeed_3800 1 0 decap_w0
xfeed_31699 1 0 decap_w0
xfeed_31698 1 0 decap_w0
xfeed_31697 1 0 decap_w0
xfeed_31696 1 0 decap_w0
xfeed_31695 1 0 decap_w0
xfeed_31694 1 0 decap_w0
xfeed_31693 1 0 decap_w0
xfeed_31692 1 0 decap_w0
xfeed_31691 1 0 decap_w0
xfeed_31690 1 0 decap_w0
xfeed_26309 1 0 decap_w0
xfeed_26308 1 0 decap_w0
xfeed_26307 1 0 decap_w0
xfeed_26306 1 0 decap_w0
xfeed_26305 1 0 decap_w0
xfeed_26304 1 0 decap_w0
xfeed_26303 1 0 decap_w0
xfeed_26302 1 0 decap_w0
xfeed_26301 1 0 decap_w0
xfeed_26300 1 0 decap_w0
xfeed_25699 1 0 decap_w0
xfeed_25698 1 0 decap_w0
xfeed_25697 1 0 decap_w0
xfeed_25696 1 0 decap_w0
xfeed_25695 1 0 decap_w0
xfeed_25694 1 0 decap_w0
xfeed_25693 1 0 decap_w0
xfeed_25692 1 0 decap_w0
xfeed_25691 1 0 decap_w0
xfeed_25690 1 0 decap_w0
xfeed_21389 1 0 decap_w0
xfeed_21388 1 0 decap_w0
xfeed_21387 1 0 decap_w0
xfeed_21386 1 0 decap_w0
xfeed_21385 1 0 decap_w0
xfeed_21384 1 0 decap_w0
xfeed_21383 1 0 decap_w0
xfeed_21382 1 0 decap_w0
xfeed_21381 1 0 decap_w0
xfeed_21380 1 0 decap_w0
xfeed_20859 1 0 decap_w0
xfeed_20858 1 0 decap_w0
xfeed_20857 1 0 decap_w0
xfeed_20856 1 0 decap_w0
xfeed_20855 1 0 decap_w0
xfeed_20854 1 0 decap_w0
xfeed_20853 1 0 decap_w0
xfeed_20852 1 0 decap_w0
xfeed_20851 1 0 decap_w0
xfeed_20850 1 0 decap_w0
xfeed_15385 1 0 decap_w0
xfeed_15384 1 0 decap_w0
xfeed_15383 1 0 decap_w0
xfeed_15382 1 0 decap_w0
xfeed_15381 1 0 tie
xfeed_15380 1 0 decap_w0
xfeed_11079 1 0 decap_w0
xfeed_11078 1 0 decap_w0
xfeed_11077 1 0 decap_w0
xfeed_11076 1 0 decap_w0
xfeed_11075 1 0 decap_w0
xfeed_11074 1 0 decap_w0
xfeed_11073 1 0 decap_w0
xfeed_11072 1 0 decap_w0
xfeed_11071 1 0 decap_w0
xfeed_11070 1 0 decap_w0
xfeed_10546 1 0 decap_w0
xfeed_10545 1 0 decap_w0
xfeed_10544 1 0 decap_w0
xfeed_10543 1 0 decap_w0
xfeed_10542 1 0 decap_w0
xfeed_10541 1 0 decap_w0
xfeed_10540 1 0 decap_w0
xfeed_19699 1 0 decap_w0
xfeed_19698 1 0 decap_w0
xfeed_19697 1 0 decap_w0
xfeed_19696 1 0 decap_w0
xfeed_19695 1 0 decap_w0
xfeed_19694 1 0 decap_w0
xfeed_19693 1 0 decap_w0
xfeed_19692 1 0 decap_w0
xfeed_19691 1 0 decap_w0
xfeed_19690 1 0 decap_w0
xfeed_15389 1 0 decap_w0
xfeed_15388 1 0 decap_w0
xfeed_15387 1 0 decap_w0
xfeed_15386 1 0 decap_w0
xfeed_14859 1 0 decap_w0
xfeed_14858 1 0 decap_w0
xfeed_14857 1 0 decap_w0
xfeed_14856 1 0 decap_w0
xfeed_14855 1 0 decap_w0
xfeed_14854 1 0 decap_w0
xfeed_14853 1 0 decap_w0
xfeed_14852 1 0 decap_w0
xfeed_14851 1 0 decap_w0
xfeed_14850 1 0 decap_w0
xfeed_10549 1 0 decap_w0
xfeed_10548 1 0 decap_w0
xfeed_10547 1 0 decap_w0
xfeed_9189 1 0 decap_w0
xfeed_9188 1 0 decap_w0
xfeed_9187 1 0 decap_w0
xfeed_9186 1 0 decap_w0
xfeed_9185 1 0 decap_w0
xfeed_9184 1 0 decap_w0
xfeed_9183 1 0 decap_w0
xfeed_9182 1 0 decap_w0
xfeed_9181 1 0 decap_w0
xfeed_9180 1 0 decap_w0
xfeed_8659 1 0 decap_w0
xfeed_8658 1 0 decap_w0
xfeed_8657 1 0 decap_w0
xfeed_8656 1 0 decap_w0
xfeed_8655 1 0 decap_w0
xfeed_8654 1 0 decap_w0
xfeed_8653 1 0 decap_w0
xfeed_8652 1 0 decap_w0
xfeed_8651 1 0 decap_w0
xfeed_8650 1 0 decap_w0
xfeed_4349 1 0 decap_w0
xfeed_4348 1 0 decap_w0
xfeed_4347 1 0 decap_w0
xfeed_4346 1 0 decap_w0
xfeed_4345 1 0 decap_w0
xfeed_4344 1 0 decap_w0
xfeed_4343 1 0 decap_w0
xfeed_4342 1 0 decap_w0
xfeed_4341 1 0 decap_w0
xfeed_4340 1 0 decap_w0
xfeed_3819 1 0 decap_w0
xfeed_3818 1 0 decap_w0
xfeed_3817 1 0 decap_w0
xfeed_3816 1 0 decap_w0
xfeed_3815 1 0 decap_w0
xfeed_3814 1 0 decap_w0
xfeed_3813 1 0 decap_w0
xfeed_3812 1 0 decap_w0
xfeed_3811 1 0 decap_w0
xfeed_3810 1 0 decap_w0
xfeed_26319 1 0 decap_w0
xfeed_26318 1 0 decap_w0
xfeed_26317 1 0 decap_w0
xfeed_26316 1 0 decap_w0
xfeed_26315 1 0 decap_w0
xfeed_26314 1 0 decap_w0
xfeed_26313 1 0 decap_w0
xfeed_26312 1 0 decap_w0
xfeed_26311 1 0 decap_w0
xfeed_26310 1 0 decap_w0
xfeed_22009 1 0 decap_w0
xfeed_22008 1 0 decap_w0
xfeed_22007 1 0 decap_w0
xfeed_22006 1 0 decap_w0
xfeed_22005 1 0 decap_w0
xfeed_22004 1 0 decap_w0
xfeed_22003 1 0 decap_w0
xfeed_22002 1 0 decap_w0
xfeed_22001 1 0 decap_w0
xfeed_22000 1 0 decap_w0
xfeed_21399 1 0 decap_w0
xfeed_21398 1 0 decap_w0
xfeed_21397 1 0 decap_w0
xfeed_21396 1 0 decap_w0
xfeed_21395 1 0 decap_w0
xfeed_21394 1 0 decap_w0
xfeed_21393 1 0 decap_w0
xfeed_21392 1 0 decap_w0
xfeed_21391 1 0 decap_w0
xfeed_21390 1 0 decap_w0
xfeed_20869 1 0 decap_w0
xfeed_20868 1 0 decap_w0
xfeed_20867 1 0 decap_w0
xfeed_20866 1 0 decap_w0
xfeed_20865 1 0 decap_w0
xfeed_20864 1 0 decap_w0
xfeed_20863 1 0 decap_w0
xfeed_20862 1 0 decap_w0
xfeed_20861 1 0 decap_w0
xfeed_20860 1 0 decap_w0
xfeed_16009 1 0 decap_w0
xfeed_16008 1 0 decap_w0
xfeed_16007 1 0 decap_w0
xfeed_16006 1 0 decap_w0
xfeed_16005 1 0 decap_w0
xfeed_16004 1 0 decap_w0
xfeed_16003 1 0 decap_w0
xfeed_16002 1 0 decap_w0
xfeed_16001 1 0 decap_w0
xfeed_16000 1 0 decap_w0
xfeed_15392 1 0 decap_w0
xfeed_15391 1 0 decap_w0
xfeed_15390 1 0 decap_w0
xfeed_11089 1 0 decap_w0
xfeed_11088 1 0 decap_w0
xfeed_11087 1 0 decap_w0
xfeed_11086 1 0 decap_w0
xfeed_11085 1 0 decap_w0
xfeed_11084 1 0 decap_w0
xfeed_11083 1 0 decap_w0
xfeed_11082 1 0 decap_w0
xfeed_11081 1 0 decap_w0
xfeed_11080 1 0 decap_w0
xfeed_10553 1 0 decap_w0
xfeed_10552 1 0 decap_w0
xfeed_10551 1 0 decap_w0
xfeed_10550 1 0 decap_w0
xfeed_15399 1 0 decap_w0
xfeed_15398 1 0 decap_w0
xfeed_15397 1 0 decap_w0
xfeed_15396 1 0 decap_w0
xfeed_15395 1 0 decap_w0
xfeed_15394 1 0 decap_w0
xfeed_15393 1 0 decap_w0
xfeed_14869 1 0 decap_w0
xfeed_14868 1 0 decap_w0
xfeed_14867 1 0 decap_w0
xfeed_14866 1 0 decap_w0
xfeed_14865 1 0 decap_w0
xfeed_14864 1 0 decap_w0
xfeed_14863 1 0 decap_w0
xfeed_14862 1 0 decap_w0
xfeed_14861 1 0 decap_w0
xfeed_14860 1 0 decap_w0
xfeed_10559 1 0 decap_w0
xfeed_10558 1 0 decap_w0
xfeed_10557 1 0 decap_w0
xfeed_10556 1 0 decap_w0
xfeed_10555 1 0 decap_w0
xfeed_10554 1 0 decap_w0
xfeed_9199 1 0 decap_w0
xfeed_9198 1 0 decap_w0
xfeed_9197 1 0 decap_w0
xfeed_9196 1 0 decap_w0
xfeed_9195 1 0 decap_w0
xfeed_9194 1 0 decap_w0
xfeed_9193 1 0 decap_w0
xfeed_9192 1 0 decap_w0
xfeed_9191 1 0 decap_w0
xfeed_9190 1 0 decap_w0
xfeed_8669 1 0 decap_w0
xfeed_8668 1 0 decap_w0
xfeed_8667 1 0 decap_w0
xfeed_8666 1 0 decap_w0
xfeed_8665 1 0 decap_w0
xfeed_8664 1 0 decap_w0
xfeed_8663 1 0 decap_w0
xfeed_8662 1 0 decap_w0
xfeed_8661 1 0 decap_w0
xfeed_8660 1 0 decap_w0
xfeed_4359 1 0 decap_w0
xfeed_4358 1 0 decap_w0
xfeed_4357 1 0 decap_w0
xfeed_4356 1 0 decap_w0
xfeed_4355 1 0 decap_w0
xfeed_4354 1 0 decap_w0
xfeed_4353 1 0 decap_w0
xfeed_4352 1 0 decap_w0
xfeed_4351 1 0 decap_w0
xfeed_4350 1 0 decap_w0
xfeed_3829 1 0 decap_w0
xfeed_3828 1 0 decap_w0
xfeed_3827 1 0 decap_w0
xfeed_3826 1 0 decap_w0
xfeed_3825 1 0 decap_w0
xfeed_3824 1 0 decap_w0
xfeed_3823 1 0 decap_w0
xfeed_3822 1 0 decap_w0
xfeed_3821 1 0 decap_w0
xfeed_3820 1 0 decap_w0
xfeed_26329 1 0 decap_w0
xfeed_26328 1 0 decap_w0
xfeed_26327 1 0 decap_w0
xfeed_26326 1 0 decap_w0
xfeed_26325 1 0 decap_w0
xfeed_26324 1 0 decap_w0
xfeed_26323 1 0 decap_w0
xfeed_26322 1 0 decap_w0
xfeed_26321 1 0 decap_w0
xfeed_26320 1 0 decap_w0
xfeed_22019 1 0 decap_w0
xfeed_22018 1 0 decap_w0
xfeed_22017 1 0 decap_w0
xfeed_22016 1 0 decap_w0
xfeed_22015 1 0 decap_w0
xfeed_22014 1 0 decap_w0
xfeed_22013 1 0 decap_w0
xfeed_22012 1 0 decap_w0
xfeed_22011 1 0 decap_w0
xfeed_22010 1 0 decap_w0
xfeed_20879 1 0 decap_w0
xfeed_20878 1 0 decap_w0
xfeed_20877 1 0 decap_w0
xfeed_20876 1 0 decap_w0
xfeed_20875 1 0 decap_w0
xfeed_20874 1 0 decap_w0
xfeed_20873 1 0 decap_w0
xfeed_20872 1 0 decap_w0
xfeed_20871 1 0 decap_w0
xfeed_20870 1 0 decap_w0
xfeed_16019 1 0 decap_w0
xfeed_16018 1 0 decap_w0
xfeed_16017 1 0 decap_w0
xfeed_16016 1 0 decap_w0
xfeed_16015 1 0 decap_w0
xfeed_16014 1 0 decap_w0
xfeed_16013 1 0 decap_w0
xfeed_16012 1 0 decap_w0
xfeed_16011 1 0 decap_w0
xfeed_16010 1 0 decap_w0
xfeed_11099 1 0 decap_w0
xfeed_11098 1 0 decap_w0
xfeed_11097 1 0 decap_w0
xfeed_11096 1 0 decap_w0
xfeed_11095 1 0 decap_w0
xfeed_11094 1 0 decap_w0
xfeed_11093 1 0 decap_w0
xfeed_11092 1 0 decap_w0
xfeed_11091 1 0 decap_w0
xfeed_11090 1 0 decap_w0
xfeed_10560 1 0 decap_w0
xfeed_14879 1 0 decap_w0
xfeed_14878 1 0 decap_w0
xfeed_14877 1 0 decap_w0
xfeed_14876 1 0 decap_w0
xfeed_14875 1 0 decap_w0
xfeed_14874 1 0 decap_w0
xfeed_14873 1 0 decap_w0
xfeed_14872 1 0 decap_w0
xfeed_14871 1 0 decap_w0
xfeed_14870 1 0 decap_w0
xfeed_10569 1 0 decap_w0
xfeed_10568 1 0 decap_w0
xfeed_10567 1 0 decap_w0
xfeed_10566 1 0 decap_w0
xfeed_10565 1 0 decap_w0
xfeed_10564 1 0 decap_w0
xfeed_10563 1 0 decap_w0
xfeed_10562 1 0 decap_w0
xfeed_10561 1 0 decap_w0
xfeed_8677 1 0 decap_w0
xfeed_8676 1 0 decap_w0
xfeed_8675 1 0 decap_w0
xfeed_8674 1 0 decap_w0
xfeed_8673 1 0 decap_w0
xfeed_8672 1 0 decap_w0
xfeed_8671 1 0 decap_w0
xfeed_8670 1 0 decap_w0
xfeed_4369 1 0 decap_w0
xfeed_4368 1 0 decap_w0
xfeed_4367 1 0 decap_w0
xfeed_4366 1 0 decap_w0
xfeed_4365 1 0 decap_w0
xfeed_4364 1 0 decap_w0
xfeed_4363 1 0 decap_w0
xfeed_4362 1 0 decap_w0
xfeed_4361 1 0 decap_w0
xfeed_4360 1 0 decap_w0
xfeed_3838 1 0 decap_w0
xfeed_3837 1 0 decap_w0
xfeed_3836 1 0 decap_w0
xfeed_3835 1 0 decap_w0
xfeed_3834 1 0 decap_w0
xfeed_3833 1 0 decap_w0
xfeed_3832 1 0 decap_w0
xfeed_3831 1 0 decap_w0
xfeed_3830 1 0 decap_w0
xfeed_31809 1 0 decap_w0
xfeed_31808 1 0 decap_w0
xfeed_31807 1 0 decap_w0
xfeed_31806 1 0 decap_w0
xfeed_31805 1 0 decap_w0
xfeed_31804 1 0 decap_w0
xfeed_31803 1 0 decap_w0
xfeed_31802 1 0 decap_w0
xfeed_31801 1 0 decap_w0
xfeed_31800 1 0 decap_w0
xfeed_26339 1 0 decap_w0
xfeed_26338 1 0 decap_w0
xfeed_26337 1 0 decap_w0
xfeed_26336 1 0 decap_w0
xfeed_26335 1 0 decap_w0
xfeed_26334 1 0 decap_w0
xfeed_26333 1 0 decap_w0
xfeed_26332 1 0 decap_w0
xfeed_26331 1 0 decap_w0
xfeed_26330 1 0 decap_w0
xfeed_25809 1 0 decap_w0
xfeed_25808 1 0 decap_w0
xfeed_25807 1 0 decap_w0
xfeed_25806 1 0 decap_w0
xfeed_25805 1 0 decap_w0
xfeed_25804 1 0 decap_w0
xfeed_25803 1 0 decap_w0
xfeed_25802 1 0 decap_w0
xfeed_25801 1 0 decap_w0
xfeed_25800 1 0 decap_w0
xfeed_22029 1 0 decap_w0
xfeed_22028 1 0 decap_w0
xfeed_22027 1 0 decap_w0
xfeed_22026 1 0 decap_w0
xfeed_22025 1 0 decap_w0
xfeed_22024 1 0 decap_w0
xfeed_22023 1 0 decap_w0
xfeed_22022 1 0 decap_w0
xfeed_22021 1 0 decap_w0
xfeed_22020 1 0 decap_w0
xfeed_20889 1 0 decap_w0
xfeed_20888 1 0 decap_w0
xfeed_20887 1 0 decap_w0
xfeed_20886 1 0 decap_w0
xfeed_20885 1 0 decap_w0
xfeed_20884 1 0 decap_w0
xfeed_20883 1 0 decap_w0
xfeed_20882 1 0 decap_w0
xfeed_20881 1 0 decap_w0
xfeed_20880 1 0 decap_w0
xfeed_19804 1 0 decap_w0
xfeed_19803 1 0 decap_w0
xfeed_19802 1 0 decap_w0
xfeed_19801 1 0 decap_w0
xfeed_19800 1 0 decap_w0
xfeed_16029 1 0 decap_w0
xfeed_16028 1 0 decap_w0
xfeed_16027 1 0 decap_w0
xfeed_16026 1 0 decap_w0
xfeed_16025 1 0 decap_w0
xfeed_16024 1 0 decap_w0
xfeed_16023 1 0 decap_w0
xfeed_16022 1 0 decap_w0
xfeed_16021 1 0 decap_w0
xfeed_16020 1 0 decap_w0
xfeed_8679 1 0 decap_w0
xfeed_8678 1 0 decap_w0
xfeed_3839 1 0 decap_w0
xfeed_19809 1 0 decap_w0
xfeed_19808 1 0 decap_w0
xfeed_19807 1 0 decap_w0
xfeed_19806 1 0 decap_w0
xfeed_19805 1 0 decap_w0
xfeed_14889 1 0 decap_w0
xfeed_14888 1 0 decap_w0
xfeed_14887 1 0 decap_w0
xfeed_14886 1 0 decap_w0
xfeed_14885 1 0 decap_w0
xfeed_14884 1 0 decap_w0
xfeed_14883 1 0 decap_w0
xfeed_14882 1 0 decap_w0
xfeed_14881 1 0 decap_w0
xfeed_14880 1 0 decap_w0
xfeed_10579 1 0 decap_w0
xfeed_10578 1 0 decap_w0
xfeed_10577 1 0 decap_w0
xfeed_10576 1 0 decap_w0
xfeed_10575 1 0 decap_w0
xfeed_10574 1 0 decap_w0
xfeed_10573 1 0 decap_w0
xfeed_10572 1 0 decap_w0
xfeed_10571 1 0 decap_w0
xfeed_10570 1 0 decap_w0
xfeed_8684 1 0 tie
xfeed_8683 1 0 decap_w0
xfeed_8682 1 0 decap_w0
xfeed_8681 1 0 decap_w0
xfeed_8680 1 0 decap_w0
xfeed_4379 1 0 decap_w0
xfeed_4378 1 0 decap_w0
xfeed_4377 1 0 decap_w0
xfeed_4376 1 0 decap_w0
xfeed_4375 1 0 decap_w0
xfeed_4374 1 0 decap_w0
xfeed_4373 1 0 decap_w0
xfeed_4372 1 0 decap_w0
xfeed_4371 1 0 decap_w0
xfeed_4370 1 0 decap_w0
xfeed_3845 1 0 decap_w0
xfeed_3844 1 0 decap_w0
xfeed_3843 1 0 decap_w0
xfeed_3842 1 0 decap_w0
xfeed_3841 1 0 decap_w0
xfeed_3840 1 0 decap_w0
xfeed_31819 1 0 decap_w0
xfeed_31818 1 0 decap_w0
xfeed_31817 1 0 decap_w0
xfeed_31816 1 0 decap_w0
xfeed_31815 1 0 decap_w0
xfeed_31814 1 0 decap_w0
xfeed_31813 1 0 decap_w0
xfeed_31812 1 0 decap_w0
xfeed_31811 1 0 decap_w0
xfeed_31810 1 0 decap_w0
xfeed_26349 1 0 decap_w0
xfeed_26348 1 0 decap_w0
xfeed_26347 1 0 decap_w0
xfeed_26346 1 0 decap_w0
xfeed_26345 1 0 decap_w0
xfeed_26344 1 0 decap_w0
xfeed_26343 1 0 decap_w0
xfeed_26342 1 0 decap_w0
xfeed_26341 1 0 decap_w0
xfeed_26340 1 0 decap_w0
xfeed_25819 1 0 decap_w0
xfeed_25818 1 0 decap_w0
xfeed_25817 1 0 decap_w0
xfeed_25816 1 0 decap_w0
xfeed_25815 1 0 decap_w0
xfeed_25814 1 0 decap_w0
xfeed_25813 1 0 decap_w0
xfeed_25812 1 0 decap_w0
xfeed_25811 1 0 decap_w0
xfeed_25810 1 0 decap_w0
xfeed_22039 1 0 decap_w0
xfeed_22038 1 0 decap_w0
xfeed_22037 1 0 decap_w0
xfeed_22036 1 0 decap_w0
xfeed_22035 1 0 decap_w0
xfeed_22034 1 0 decap_w0
xfeed_22033 1 0 decap_w0
xfeed_22032 1 0 decap_w0
xfeed_22031 1 0 decap_w0
xfeed_22030 1 0 decap_w0
xfeed_21509 1 0 decap_w0
xfeed_21508 1 0 decap_w0
xfeed_21507 1 0 decap_w0
xfeed_21506 1 0 decap_w0
xfeed_21505 1 0 decap_w0
xfeed_21504 1 0 decap_w0
xfeed_21503 1 0 decap_w0
xfeed_21502 1 0 decap_w0
xfeed_21501 1 0 decap_w0
xfeed_21500 1 0 decap_w0
xfeed_20899 1 0 decap_w0
xfeed_20898 1 0 decap_w0
xfeed_20897 1 0 decap_w0
xfeed_20896 1 0 decap_w0
xfeed_20895 1 0 decap_w0
xfeed_20894 1 0 decap_w0
xfeed_20893 1 0 decap_w0
xfeed_20892 1 0 decap_w0
xfeed_20891 1 0 decap_w0
xfeed_20890 1 0 decap_w0
xfeed_19811 1 0 decap_w0
xfeed_19810 1 0 decap_w0
xfeed_16039 1 0 decap_w0
xfeed_16038 1 0 decap_w0
xfeed_16037 1 0 decap_w0
xfeed_16036 1 0 decap_w0
xfeed_16035 1 0 decap_w0
xfeed_16034 1 0 decap_w0
xfeed_16033 1 0 decap_w0
xfeed_16032 1 0 decap_w0
xfeed_16031 1 0 decap_w0
xfeed_16030 1 0 decap_w0
xfeed_15509 1 0 decap_w0
xfeed_15508 1 0 decap_w0
xfeed_15507 1 0 decap_w0
xfeed_15506 1 0 decap_w0
xfeed_15505 1 0 decap_w0
xfeed_15504 1 0 decap_w0
xfeed_15503 1 0 decap_w0
xfeed_15502 1 0 decap_w0
xfeed_15501 1 0 decap_w0
xfeed_15500 1 0 decap_w0
xfeed_8689 1 0 decap_w0
xfeed_8688 1 0 decap_w0
xfeed_8687 1 0 decap_w0
xfeed_8686 1 0 decap_w0
xfeed_8685 1 0 decap_w0
xfeed_3849 1 0 decap_w0
xfeed_3848 1 0 decap_w0
xfeed_3847 1 0 decap_w0
xfeed_3846 1 0 decap_w0
xfeed_19819 1 0 decap_w0
xfeed_19818 1 0 decap_w0
xfeed_19817 1 0 decap_w0
xfeed_19816 1 0 decap_w0
xfeed_19815 1 0 decap_w0
xfeed_19814 1 0 decap_w0
xfeed_19813 1 0 decap_w0
xfeed_19812 1 0 decap_w0
xfeed_14899 1 0 decap_w0
xfeed_14898 1 0 decap_w0
xfeed_14897 1 0 decap_w0
xfeed_14896 1 0 decap_w0
xfeed_14895 1 0 decap_w0
xfeed_14894 1 0 decap_w0
xfeed_14893 1 0 decap_w0
xfeed_14892 1 0 decap_w0
xfeed_14891 1 0 decap_w0
xfeed_14890 1 0 decap_w0
xfeed_10589 1 0 decap_w0
xfeed_10588 1 0 decap_w0
xfeed_10587 1 0 decap_w0
xfeed_10586 1 0 decap_w0
xfeed_10585 1 0 decap_w0
xfeed_10584 1 0 decap_w0
xfeed_10583 1 0 decap_w0
xfeed_10582 1 0 decap_w0
xfeed_10581 1 0 decap_w0
xfeed_10580 1 0 decap_w0
xfeed_9309 1 0 decap_w0
xfeed_9308 1 0 decap_w0
xfeed_9307 1 0 decap_w0
xfeed_9306 1 0 decap_w0
xfeed_9305 1 0 decap_w0
xfeed_9304 1 0 decap_w0
xfeed_9303 1 0 decap_w0
xfeed_9302 1 0 decap_w0
xfeed_9301 1 0 decap_w0
xfeed_9300 1 0 decap_w0
xfeed_8691 1 0 decap_w0
xfeed_8690 1 0 decap_w0
xfeed_4389 1 0 decap_w0
xfeed_4388 1 0 decap_w0
xfeed_4387 1 0 decap_w0
xfeed_4386 1 0 decap_w0
xfeed_4385 1 0 decap_w0
xfeed_4384 1 0 decap_w0
xfeed_4383 1 0 decap_w0
xfeed_4382 1 0 decap_w0
xfeed_4381 1 0 decap_w0
xfeed_4380 1 0 decap_w0
xfeed_3852 1 0 decap_w0
xfeed_3851 1 0 decap_w0
xfeed_3850 1 0 decap_w0
xfeed_31829 1 0 decap_w0
xfeed_31828 1 0 decap_w0
xfeed_31827 1 0 decap_w0
xfeed_31826 1 0 decap_w0
xfeed_31825 1 0 decap_w0
xfeed_31824 1 0 decap_w0
xfeed_31823 1 0 decap_w0
xfeed_31822 1 0 decap_w0
xfeed_31821 1 0 decap_w0
xfeed_31820 1 0 decap_w0
xfeed_26359 1 0 decap_w0
xfeed_26358 1 0 decap_w0
xfeed_26357 1 0 decap_w0
xfeed_26356 1 0 decap_w0
xfeed_26355 1 0 decap_w0
xfeed_26354 1 0 decap_w0
xfeed_26353 1 0 decap_w0
xfeed_26352 1 0 decap_w0
xfeed_26351 1 0 decap_w0
xfeed_26350 1 0 decap_w0
xfeed_25829 1 0 decap_w0
xfeed_25828 1 0 decap_w0
xfeed_25827 1 0 decap_w0
xfeed_25826 1 0 decap_w0
xfeed_25825 1 0 decap_w0
xfeed_25824 1 0 decap_w0
xfeed_25823 1 0 decap_w0
xfeed_25822 1 0 decap_w0
xfeed_25821 1 0 decap_w0
xfeed_25820 1 0 decap_w0
xfeed_22049 1 0 decap_w0
xfeed_22048 1 0 decap_w0
xfeed_22047 1 0 decap_w0
xfeed_22046 1 0 decap_w0
xfeed_22045 1 0 decap_w0
xfeed_22044 1 0 decap_w0
xfeed_22043 1 0 decap_w0
xfeed_22042 1 0 decap_w0
xfeed_22041 1 0 decap_w0
xfeed_22040 1 0 decap_w0
xfeed_21519 1 0 decap_w0
xfeed_21518 1 0 decap_w0
xfeed_21517 1 0 decap_w0
xfeed_21516 1 0 decap_w0
xfeed_21515 1 0 decap_w0
xfeed_21514 1 0 decap_w0
xfeed_21513 1 0 decap_w0
xfeed_21512 1 0 decap_w0
xfeed_21511 1 0 decap_w0
xfeed_21510 1 0 decap_w0
xfeed_16049 1 0 decap_w0
xfeed_16048 1 0 decap_w0
xfeed_16047 1 0 decap_w0
xfeed_16046 1 0 decap_w0
xfeed_16045 1 0 decap_w0
xfeed_16044 1 0 decap_w0
xfeed_16043 1 0 decap_w0
xfeed_16042 1 0 decap_w0
xfeed_16041 1 0 decap_w0
xfeed_16040 1 0 decap_w0
xfeed_15518 1 0 decap_w0
xfeed_15517 1 0 decap_w0
xfeed_15516 1 0 decap_w0
xfeed_15515 1 0 decap_w0
xfeed_15514 1 0 decap_w0
xfeed_15513 1 0 decap_w0
xfeed_15512 1 0 decap_w0
xfeed_15511 1 0 decap_w0
xfeed_15510 1 0 decap_w0
xfeed_11209 1 0 decap_w0
xfeed_11208 1 0 decap_w0
xfeed_11207 1 0 decap_w0
xfeed_11206 1 0 decap_w0
xfeed_11205 1 0 decap_w0
xfeed_11204 1 0 decap_w0
xfeed_11203 1 0 decap_w0
xfeed_11202 1 0 decap_w0
xfeed_11201 1 0 decap_w0
xfeed_11200 1 0 decap_w0
xfeed_8699 1 0 decap_w0
xfeed_8698 1 0 decap_w0
xfeed_8697 1 0 decap_w0
xfeed_8696 1 0 decap_w0
xfeed_8695 1 0 decap_w0
xfeed_8694 1 0 decap_w0
xfeed_8693 1 0 decap_w0
xfeed_8692 1 0 decap_w0
xfeed_3859 1 0 decap_w0
xfeed_3858 1 0 decap_w0
xfeed_3857 1 0 decap_w0
xfeed_3856 1 0 decap_w0
xfeed_3855 1 0 decap_w0
xfeed_3854 1 0 decap_w0
xfeed_3853 1 0 decap_w0
xfeed_19829 1 0 decap_w0
xfeed_19828 1 0 decap_w0
xfeed_19827 1 0 decap_w0
xfeed_19826 1 0 decap_w0
xfeed_19825 1 0 decap_w0
xfeed_19824 1 0 decap_w0
xfeed_19823 1 0 tie
xfeed_19822 1 0 decap_w0
xfeed_19821 1 0 decap_w0
xfeed_19820 1 0 decap_w0
xfeed_15519 1 0 decap_w0
xfeed_10599 1 0 decap_w0
xfeed_10598 1 0 decap_w0
xfeed_10597 1 0 decap_w0
xfeed_10596 1 0 decap_w0
xfeed_10595 1 0 decap_w0
xfeed_10594 1 0 decap_w0
xfeed_10593 1 0 decap_w0
xfeed_10592 1 0 decap_w0
xfeed_10591 1 0 decap_w0
xfeed_10590 1 0 decap_w0
xfeed_9319 1 0 decap_w0
xfeed_9318 1 0 decap_w0
xfeed_9317 1 0 decap_w0
xfeed_9316 1 0 decap_w0
xfeed_9315 1 0 decap_w0
xfeed_9314 1 0 decap_w0
xfeed_9313 1 0 decap_w0
xfeed_9312 1 0 decap_w0
xfeed_9311 1 0 decap_w0
xfeed_9310 1 0 decap_w0
xfeed_5009 1 0 decap_w0
xfeed_5008 1 0 decap_w0
xfeed_5007 1 0 decap_w0
xfeed_5006 1 0 decap_w0
xfeed_5005 1 0 decap_w0
xfeed_5004 1 0 decap_w0
xfeed_5003 1 0 decap_w0
xfeed_5002 1 0 decap_w0
xfeed_5001 1 0 decap_w0
xfeed_5000 1 0 decap_w0
xfeed_4398 1 0 decap_w0
xfeed_4397 1 0 decap_w0
xfeed_4396 1 0 decap_w0
xfeed_4395 1 0 decap_w0
xfeed_4394 1 0 decap_w0
xfeed_4393 1 0 decap_w0
xfeed_4392 1 0 decap_w0
xfeed_4391 1 0 decap_w0
xfeed_4390 1 0 decap_w0
xfeed_31839 1 0 decap_w0
xfeed_31838 1 0 decap_w0
xfeed_31837 1 0 decap_w0
xfeed_31836 1 0 decap_w0
xfeed_31835 1 0 decap_w0
xfeed_31834 1 0 decap_w0
xfeed_31833 1 0 decap_w0
xfeed_31832 1 0 decap_w0
xfeed_31831 1 0 decap_w0
xfeed_31830 1 0 decap_w0
xfeed_26369 1 0 decap_w0
xfeed_26368 1 0 decap_w0
xfeed_26367 1 0 decap_w0
xfeed_26366 1 0 decap_w0
xfeed_26365 1 0 decap_w0
xfeed_26364 1 0 decap_w0
xfeed_26363 1 0 decap_w0
xfeed_26362 1 0 decap_w0
xfeed_26361 1 0 decap_w0
xfeed_26360 1 0 decap_w0
xfeed_25839 1 0 decap_w0
xfeed_25838 1 0 decap_w0
xfeed_25837 1 0 decap_w0
xfeed_25836 1 0 decap_w0
xfeed_25835 1 0 decap_w0
xfeed_25834 1 0 decap_w0
xfeed_25833 1 0 decap_w0
xfeed_25832 1 0 decap_w0
xfeed_25831 1 0 decap_w0
xfeed_25830 1 0 decap_w0
xfeed_22059 1 0 decap_w0
xfeed_22058 1 0 decap_w0
xfeed_22057 1 0 decap_w0
xfeed_22056 1 0 decap_w0
xfeed_22055 1 0 decap_w0
xfeed_22054 1 0 decap_w0
xfeed_22053 1 0 decap_w0
xfeed_22052 1 0 decap_w0
xfeed_22051 1 0 decap_w0
xfeed_22050 1 0 decap_w0
xfeed_21529 1 0 decap_w0
xfeed_21528 1 0 decap_w0
xfeed_21527 1 0 decap_w0
xfeed_21526 1 0 decap_w0
xfeed_21525 1 0 decap_w0
xfeed_21524 1 0 decap_w0
xfeed_21523 1 0 decap_w0
xfeed_21522 1 0 decap_w0
xfeed_21521 1 0 decap_w0
xfeed_21520 1 0 decap_w0
xfeed_16059 1 0 decap_w0
xfeed_16058 1 0 decap_w0
xfeed_16057 1 0 decap_w0
xfeed_16056 1 0 decap_w0
xfeed_16055 1 0 decap_w0
xfeed_16054 1 0 decap_w0
xfeed_16053 1 0 decap_w0
xfeed_16052 1 0 decap_w0
xfeed_16051 1 0 decap_w0
xfeed_16050 1 0 decap_w0
xfeed_15525 1 0 decap_w0
xfeed_15524 1 0 decap_w0
xfeed_15523 1 0 decap_w0
xfeed_15522 1 0 decap_w0
xfeed_15521 1 0 decap_w0
xfeed_15520 1 0 decap_w0
xfeed_11219 1 0 decap_w0
xfeed_11218 1 0 decap_w0
xfeed_11217 1 0 decap_w0
xfeed_11216 1 0 decap_w0
xfeed_11215 1 0 decap_w0
xfeed_11214 1 0 decap_w0
xfeed_11213 1 0 decap_w0
xfeed_11212 1 0 decap_w0
xfeed_11211 1 0 decap_w0
xfeed_11210 1 0 decap_w0
xfeed_4399 1 0 decap_w0
xfeed_3869 1 0 decap_w0
xfeed_3868 1 0 decap_w0
xfeed_3867 1 0 decap_w0
xfeed_3866 1 0 decap_w0
xfeed_3865 1 0 decap_w0
xfeed_3864 1 0 decap_w0
xfeed_3863 1 0 decap_w0
xfeed_3862 1 0 decap_w0
xfeed_3861 1 0 decap_w0
xfeed_3860 1 0 decap_w0
xfeed_19839 1 0 decap_w0
xfeed_19838 1 0 decap_w0
xfeed_19837 1 0 decap_w0
xfeed_19836 1 0 decap_w0
xfeed_19835 1 0 decap_w0
xfeed_19834 1 0 decap_w0
xfeed_19833 1 0 decap_w0
xfeed_19832 1 0 decap_w0
xfeed_19831 1 0 decap_w0
xfeed_19830 1 0 decap_w0
xfeed_15529 1 0 decap_w0
xfeed_15528 1 0 decap_w0
xfeed_15527 1 0 decap_w0
xfeed_15526 1 0 decap_w0
xfeed_9329 1 0 decap_w0
xfeed_9328 1 0 decap_w0
xfeed_9327 1 0 decap_w0
xfeed_9326 1 0 decap_w0
xfeed_9325 1 0 decap_w0
xfeed_9324 1 0 decap_w0
xfeed_9323 1 0 decap_w0
xfeed_9322 1 0 decap_w0
xfeed_9321 1 0 decap_w0
xfeed_9320 1 0 tie
xfeed_5019 1 0 decap_w0
xfeed_5018 1 0 decap_w0
xfeed_5017 1 0 decap_w0
xfeed_5016 1 0 decap_w0
xfeed_5015 1 0 decap_w0
xfeed_5014 1 0 decap_w0
xfeed_5013 1 0 decap_w0
xfeed_5012 1 0 decap_w0
xfeed_5011 1 0 decap_w0
xfeed_5010 1 0 decap_w0
xsubckt_88_xor2_x0 1 0 44 53 148 xor2_x0
xfeed_31849 1 0 decap_w0
xfeed_31848 1 0 decap_w0
xfeed_31847 1 0 decap_w0
xfeed_31846 1 0 decap_w0
xfeed_31845 1 0 decap_w0
xfeed_31844 1 0 decap_w0
xfeed_31843 1 0 decap_w0
xfeed_31842 1 0 decap_w0
xfeed_31841 1 0 decap_w0
xfeed_31840 1 0 decap_w0
xfeed_26379 1 0 decap_w0
xfeed_26378 1 0 decap_w0
xfeed_26377 1 0 decap_w0
xfeed_26376 1 0 decap_w0
xfeed_26375 1 0 decap_w0
xfeed_26374 1 0 decap_w0
xfeed_26373 1 0 decap_w0
xfeed_26372 1 0 decap_w0
xfeed_26371 1 0 decap_w0
xfeed_26370 1 0 decap_w0
xfeed_25849 1 0 decap_w0
xfeed_25848 1 0 decap_w0
xfeed_25847 1 0 decap_w0
xfeed_25846 1 0 decap_w0
xfeed_25845 1 0 decap_w0
xfeed_25844 1 0 decap_w0
xfeed_25843 1 0 decap_w0
xfeed_25842 1 0 decap_w0
xfeed_25841 1 0 decap_w0
xfeed_25840 1 0 decap_w0
xfeed_22069 1 0 decap_w0
xfeed_22068 1 0 decap_w0
xfeed_22067 1 0 decap_w0
xfeed_22066 1 0 decap_w0
xfeed_22065 1 0 decap_w0
xfeed_22064 1 0 decap_w0
xfeed_22063 1 0 decap_w0
xfeed_22062 1 0 decap_w0
xfeed_22061 1 0 decap_w0
xfeed_22060 1 0 decap_w0
xfeed_21539 1 0 decap_w0
xfeed_21538 1 0 decap_w0
xfeed_21537 1 0 decap_w0
xfeed_21536 1 0 tie
xfeed_21535 1 0 decap_w0
xfeed_21534 1 0 decap_w0
xfeed_21533 1 0 decap_w0
xfeed_21532 1 0 decap_w0
xfeed_21531 1 0 decap_w0
xfeed_21530 1 0 decap_w0
xfeed_16069 1 0 decap_w0
xfeed_16068 1 0 decap_w0
xfeed_16067 1 0 decap_w0
xfeed_16066 1 0 decap_w0
xfeed_16065 1 0 decap_w0
xfeed_16064 1 0 decap_w0
xfeed_16063 1 0 decap_w0
xfeed_16062 1 0 decap_w0
xfeed_16061 1 0 decap_w0
xfeed_16060 1 0 decap_w0
xfeed_15532 1 0 decap_w0
xfeed_15531 1 0 decap_w0
xfeed_15530 1 0 decap_w0
xfeed_11229 1 0 decap_w0
xfeed_11228 1 0 decap_w0
xfeed_11227 1 0 decap_w0
xfeed_11226 1 0 decap_w0
xfeed_11225 1 0 decap_w0
xfeed_11224 1 0 decap_w0
xfeed_11223 1 0 decap_w0
xfeed_11222 1 0 decap_w0
xfeed_11221 1 0 decap_w0
xfeed_11220 1 0 decap_w0
xfeed_3879 1 0 decap_w0
xfeed_3878 1 0 tie
xfeed_3877 1 0 decap_w0
xfeed_3876 1 0 decap_w0
xfeed_3875 1 0 decap_w0
xfeed_3874 1 0 decap_w0
xfeed_3873 1 0 decap_w0
xfeed_3872 1 0 decap_w0
xfeed_3871 1 0 decap_w0
xfeed_3870 1 0 decap_w0
xfeed_19849 1 0 decap_w0
xfeed_19848 1 0 decap_w0
xfeed_19847 1 0 decap_w0
xfeed_19846 1 0 decap_w0
xfeed_19845 1 0 decap_w0
xfeed_19844 1 0 decap_w0
xfeed_19843 1 0 decap_w0
xfeed_19842 1 0 decap_w0
xfeed_19841 1 0 decap_w0
xfeed_19840 1 0 decap_w0
xfeed_15539 1 0 decap_w0
xfeed_15538 1 0 decap_w0
xfeed_15537 1 0 decap_w0
xfeed_15536 1 0 decap_w0
xfeed_15535 1 0 decap_w0
xfeed_15534 1 0 decap_w0
xfeed_15533 1 0 decap_w0
xfeed_9339 1 0 decap_w0
xfeed_9338 1 0 decap_w0
xfeed_9337 1 0 decap_w0
xfeed_9336 1 0 decap_w0
xfeed_9335 1 0 decap_w0
xfeed_9334 1 0 decap_w0
xfeed_9333 1 0 decap_w0
xfeed_9332 1 0 decap_w0
xfeed_9331 1 0 decap_w0
xfeed_9330 1 0 decap_w0
xfeed_8809 1 0 decap_w0
xfeed_8808 1 0 decap_w0
xfeed_8807 1 0 decap_w0
xfeed_8806 1 0 decap_w0
xfeed_8805 1 0 decap_w0
xfeed_8804 1 0 decap_w0
xfeed_8803 1 0 decap_w0
xfeed_8802 1 0 decap_w0
xfeed_8801 1 0 decap_w0
xfeed_8800 1 0 decap_w0
xfeed_5029 1 0 decap_w0
xfeed_5028 1 0 decap_w0
xfeed_5027 1 0 decap_w0
xfeed_5026 1 0 decap_w0
xfeed_5025 1 0 decap_w0
xfeed_5024 1 0 decap_w0
xfeed_5023 1 0 decap_w0
xfeed_5022 1 0 decap_w0
xfeed_5021 1 0 decap_w0
xfeed_5020 1 0 decap_w0
xfeed_31859 1 0 decap_w0
xfeed_31858 1 0 decap_w0
xfeed_31857 1 0 decap_w0
xfeed_31856 1 0 decap_w0
xfeed_31855 1 0 decap_w0
xfeed_31854 1 0 decap_w0
xfeed_31853 1 0 decap_w0
xfeed_31852 1 0 decap_w0
xfeed_31851 1 0 decap_w0
xfeed_31850 1 0 decap_w0
xfeed_26389 1 0 decap_w0
xfeed_26388 1 0 decap_w0
xfeed_26387 1 0 decap_w0
xfeed_26386 1 0 decap_w0
xfeed_26385 1 0 decap_w0
xfeed_26384 1 0 decap_w0
xfeed_26383 1 0 decap_w0
xfeed_26382 1 0 decap_w0
xfeed_26381 1 0 decap_w0
xfeed_26380 1 0 decap_w0
xfeed_25859 1 0 decap_w0
xfeed_25858 1 0 decap_w0
xfeed_25857 1 0 decap_w0
xfeed_25856 1 0 decap_w0
xfeed_25855 1 0 decap_w0
xfeed_25854 1 0 decap_w0
xfeed_25853 1 0 decap_w0
xfeed_25852 1 0 decap_w0
xfeed_25851 1 0 decap_w0
xfeed_25850 1 0 decap_w0
xfeed_22079 1 0 decap_w0
xfeed_22078 1 0 decap_w0
xfeed_22077 1 0 decap_w0
xfeed_22076 1 0 decap_w0
xfeed_22075 1 0 decap_w0
xfeed_22074 1 0 decap_w0
xfeed_22073 1 0 decap_w0
xfeed_22072 1 0 decap_w0
xfeed_22071 1 0 decap_w0
xfeed_22070 1 0 decap_w0
xfeed_21549 1 0 decap_w0
xfeed_21548 1 0 decap_w0
xfeed_21547 1 0 decap_w0
xfeed_21546 1 0 decap_w0
xfeed_21545 1 0 decap_w0
xfeed_21544 1 0 decap_w0
xfeed_21543 1 0 decap_w0
xfeed_21542 1 0 decap_w0
xfeed_21541 1 0 decap_w0
xfeed_21540 1 0 decap_w0
xfeed_16078 1 0 decap_w0
xfeed_16077 1 0 decap_w0
xfeed_16076 1 0 decap_w0
xfeed_16075 1 0 decap_w0
xfeed_16074 1 0 decap_w0
xfeed_16073 1 0 decap_w0
xfeed_16072 1 0 decap_w0
xfeed_16071 1 0 decap_w0
xfeed_16070 1 0 decap_w0
xfeed_11239 1 0 decap_w0
xfeed_11238 1 0 decap_w0
xfeed_11237 1 0 decap_w0
xfeed_11236 1 0 decap_w0
xfeed_11235 1 0 decap_w0
xfeed_11234 1 0 decap_w0
xfeed_11233 1 0 decap_w0
xfeed_11232 1 0 decap_w0
xfeed_11231 1 0 decap_w0
xfeed_11230 1 0 decap_w0
xfeed_10700 1 0 decap_w0
xfeed_3889 1 0 decap_w0
xfeed_3888 1 0 decap_w0
xfeed_3887 1 0 decap_w0
xfeed_3886 1 0 decap_w0
xfeed_3885 1 0 decap_w0
xfeed_3884 1 0 decap_w0
xfeed_3883 1 0 decap_w0
xfeed_3882 1 0 decap_w0
xfeed_3881 1 0 decap_w0
xfeed_3880 1 0 decap_w0
xfeed_19859 1 0 decap_w0
xfeed_19858 1 0 decap_w0
xfeed_19857 1 0 decap_w0
xfeed_19856 1 0 decap_w0
xfeed_19855 1 0 decap_w0
xfeed_19854 1 0 decap_w0
xfeed_19853 1 0 decap_w0
xfeed_19852 1 0 decap_w0
xfeed_19851 1 0 decap_w0
xfeed_19850 1 0 decap_w0
xfeed_16079 1 0 decap_w0
xfeed_15549 1 0 decap_w0
xfeed_15548 1 0 decap_w0
xfeed_15547 1 0 decap_w0
xfeed_15546 1 0 decap_w0
xfeed_15545 1 0 decap_w0
xfeed_15544 1 0 decap_w0
xfeed_15543 1 0 decap_w0
xfeed_15542 1 0 decap_w0
xfeed_15541 1 0 decap_w0
xfeed_15540 1 0 decap_w0
xfeed_10709 1 0 decap_w0
xfeed_10708 1 0 decap_w0
xfeed_10707 1 0 decap_w0
xfeed_10706 1 0 decap_w0
xfeed_10705 1 0 decap_w0
xfeed_10704 1 0 decap_w0
xfeed_10703 1 0 decap_w0
xfeed_10702 1 0 decap_w0
xfeed_10701 1 0 decap_w0
xfeed_9349 1 0 decap_w0
xfeed_9348 1 0 decap_w0
xfeed_9347 1 0 decap_w0
xfeed_9346 1 0 decap_w0
xfeed_9345 1 0 decap_w0
xfeed_9344 1 0 decap_w0
xfeed_9343 1 0 decap_w0
xfeed_9342 1 0 decap_w0
xfeed_9341 1 0 decap_w0
xfeed_9340 1 0 decap_w0
xfeed_8817 1 0 decap_w0
xfeed_8816 1 0 decap_w0
xfeed_8815 1 0 decap_w0
xfeed_8814 1 0 decap_w0
xfeed_8813 1 0 decap_w0
xfeed_8812 1 0 decap_w0
xfeed_8811 1 0 decap_w0
xfeed_8810 1 0 decap_w0
xfeed_5039 1 0 decap_w0
xfeed_5038 1 0 decap_w0
xfeed_5037 1 0 decap_w0
xfeed_5036 1 0 decap_w0
xfeed_5035 1 0 decap_w0
xfeed_5034 1 0 decap_w0
xfeed_5033 1 0 decap_w0
xfeed_5032 1 0 decap_w0
xfeed_5031 1 0 decap_w0
xfeed_5030 1 0 decap_w0
xfeed_4509 1 0 decap_w0
xfeed_4508 1 0 decap_w0
xfeed_4507 1 0 decap_w0
xfeed_4506 1 0 decap_w0
xfeed_4505 1 0 decap_w0
xfeed_4504 1 0 decap_w0
xfeed_4503 1 0 decap_w0
xfeed_4502 1 0 decap_w0
xfeed_4501 1 0 decap_w0
xfeed_4500 1 0 decap_w0
xfeed_31869 1 0 decap_w0
xfeed_31868 1 0 decap_w0
xfeed_31867 1 0 decap_w0
xfeed_31866 1 0 decap_w0
xfeed_31865 1 0 decap_w0
xfeed_31864 1 0 decap_w0
xfeed_31863 1 0 decap_w0
xfeed_31862 1 0 decap_w0
xfeed_31861 1 0 decap_w0
xfeed_31860 1 0 decap_w0
xfeed_27009 1 0 decap_w0
xfeed_27008 1 0 decap_w0
xfeed_27007 1 0 decap_w0
xfeed_27006 1 0 decap_w0
xfeed_27005 1 0 decap_w0
xfeed_27004 1 0 decap_w0
xfeed_27003 1 0 decap_w0
xfeed_27002 1 0 decap_w0
xfeed_27001 1 0 decap_w0
xfeed_27000 1 0 decap_w0
xfeed_26399 1 0 decap_w0
xfeed_26398 1 0 decap_w0
xfeed_26397 1 0 decap_w0
xfeed_26396 1 0 decap_w0
xfeed_26395 1 0 decap_w0
xfeed_26394 1 0 decap_w0
xfeed_26393 1 0 decap_w0
xfeed_26392 1 0 decap_w0
xfeed_26391 1 0 decap_w0
xfeed_26390 1 0 decap_w0
xfeed_25869 1 0 decap_w0
xfeed_25868 1 0 decap_w0
xfeed_25867 1 0 decap_w0
xfeed_25866 1 0 decap_w0
xfeed_25865 1 0 decap_w0
xfeed_25864 1 0 decap_w0
xfeed_25863 1 0 decap_w0
xfeed_25862 1 0 decap_w0
xfeed_25861 1 0 decap_w0
xfeed_25860 1 0 decap_w0
xfeed_22089 1 0 decap_w0
xfeed_22088 1 0 decap_w0
xfeed_22087 1 0 decap_w0
xfeed_22086 1 0 decap_w0
xfeed_22085 1 0 decap_w0
xfeed_22084 1 0 decap_w0
xfeed_22083 1 0 decap_w0
xfeed_22082 1 0 decap_w0
xfeed_22081 1 0 decap_w0
xfeed_22080 1 0 decap_w0
xfeed_21559 1 0 decap_w0
xfeed_21558 1 0 decap_w0
xfeed_21557 1 0 decap_w0
xfeed_21556 1 0 decap_w0
xfeed_21555 1 0 decap_w0
xfeed_21554 1 0 decap_w0
xfeed_21553 1 0 decap_w0
xfeed_21552 1 0 decap_w0
xfeed_21551 1 0 decap_w0
xfeed_21550 1 0 decap_w0
xfeed_16085 1 0 decap_w0
xfeed_16084 1 0 decap_w0
xfeed_16083 1 0 decap_w0
xfeed_16082 1 0 decap_w0
xfeed_16081 1 0 decap_w0
xfeed_16080 1 0 decap_w0
xfeed_11246 1 0 decap_w0
xfeed_11245 1 0 decap_w0
xfeed_11244 1 0 decap_w0
xfeed_11243 1 0 decap_w0
xfeed_11242 1 0 decap_w0
xfeed_11241 1 0 decap_w0
xfeed_11240 1 0 decap_w0
xfeed_8819 1 0 decap_w0
xfeed_8818 1 0 decap_w0
xfeed_3899 1 0 decap_w0
xfeed_3898 1 0 decap_w0
xfeed_3897 1 0 decap_w0
xfeed_3896 1 0 decap_w0
xfeed_3895 1 0 decap_w0
xfeed_3894 1 0 decap_w0
xfeed_3893 1 0 decap_w0
xfeed_3892 1 0 decap_w0
xfeed_3891 1 0 decap_w0
xfeed_3890 1 0 decap_w0
xfeed_19869 1 0 decap_w0
xfeed_19868 1 0 decap_w0
xfeed_19867 1 0 decap_w0
xfeed_19866 1 0 decap_w0
xfeed_19865 1 0 decap_w0
xfeed_19864 1 0 decap_w0
xfeed_19863 1 0 decap_w0
xfeed_19862 1 0 tie
xfeed_19861 1 0 decap_w0
xfeed_19860 1 0 decap_w0
xfeed_16089 1 0 decap_w0
xfeed_16088 1 0 decap_w0
xfeed_16087 1 0 decap_w0
xfeed_16086 1 0 decap_w0
xfeed_15559 1 0 decap_w0
xfeed_15558 1 0 decap_w0
xfeed_15557 1 0 decap_w0
xfeed_15556 1 0 decap_w0
xfeed_15555 1 0 decap_w0
xfeed_15554 1 0 decap_w0
xfeed_15553 1 0 decap_w0
xfeed_15552 1 0 decap_w0
xfeed_15551 1 0 decap_w0
xfeed_15550 1 0 decap_w0
xfeed_11249 1 0 decap_w0
xfeed_11248 1 0 decap_w0
xfeed_11247 1 0 tie
xfeed_10719 1 0 decap_w0
xfeed_10718 1 0 decap_w0
xfeed_10717 1 0 decap_w0
xfeed_10716 1 0 decap_w0
xfeed_10715 1 0 decap_w0
xfeed_10714 1 0 decap_w0
xfeed_10713 1 0 decap_w0
xfeed_10712 1 0 decap_w0
xfeed_10711 1 0 decap_w0
xfeed_10710 1 0 decap_w0
xfeed_9359 1 0 decap_w0
xfeed_9358 1 0 decap_w0
xfeed_9357 1 0 decap_w0
xfeed_9356 1 0 decap_w0
xfeed_9355 1 0 decap_w0
xfeed_9354 1 0 decap_w0
xfeed_9353 1 0 decap_w0
xfeed_9352 1 0 decap_w0
xfeed_9351 1 0 decap_w0
xfeed_9350 1 0 decap_w0
xfeed_8824 1 0 decap_w0
xfeed_8823 1 0 decap_w0
xfeed_8822 1 0 decap_w0
xfeed_8821 1 0 decap_w0
xfeed_8820 1 0 decap_w0
xfeed_5049 1 0 decap_w0
xfeed_5048 1 0 decap_w0
xfeed_5047 1 0 decap_w0
xfeed_5046 1 0 decap_w0
xfeed_5045 1 0 decap_w0
xfeed_5044 1 0 decap_w0
xfeed_5043 1 0 decap_w0
xfeed_5042 1 0 decap_w0
xfeed_5041 1 0 decap_w0
xfeed_5040 1 0 decap_w0
xfeed_4519 1 0 decap_w0
xfeed_4518 1 0 decap_w0
xfeed_4517 1 0 decap_w0
xfeed_4516 1 0 decap_w0
xfeed_4515 1 0 decap_w0
xfeed_4514 1 0 decap_w0
xfeed_4513 1 0 decap_w0
xfeed_4512 1 0 decap_w0
xfeed_4511 1 0 decap_w0
xfeed_4510 1 0 decap_w0
xspare_feed_10 1 0 tie
xspare_feed_11 1 0 tie
xspare_feed_12 1 0 tie
xspare_feed_13 1 0 tie
xfeed_31879 1 0 decap_w0
xfeed_31878 1 0 decap_w0
xfeed_31877 1 0 decap_w0
xfeed_31876 1 0 decap_w0
xfeed_31875 1 0 decap_w0
xfeed_31874 1 0 decap_w0
xfeed_31873 1 0 decap_w0
xfeed_31872 1 0 decap_w0
xfeed_31871 1 0 decap_w0
xfeed_31870 1 0 decap_w0
xfeed_27019 1 0 decap_w0
xfeed_27018 1 0 decap_w0
xfeed_27017 1 0 decap_w0
xfeed_27016 1 0 decap_w0
xfeed_27015 1 0 decap_w0
xfeed_27014 1 0 decap_w0
xfeed_27013 1 0 decap_w0
xfeed_27012 1 0 decap_w0
xfeed_27011 1 0 decap_w0
xfeed_27010 1 0 decap_w0
xfeed_25879 1 0 decap_w0
xfeed_25878 1 0 decap_w0
xfeed_25877 1 0 decap_w0
xfeed_25876 1 0 decap_w0
xfeed_25875 1 0 decap_w0
xfeed_25874 1 0 decap_w0
xfeed_25873 1 0 decap_w0
xfeed_25872 1 0 decap_w0
xfeed_25871 1 0 decap_w0
xfeed_25870 1 0 decap_w0
xfeed_22099 1 0 decap_w0
xfeed_22098 1 0 decap_w0
xfeed_22097 1 0 decap_w0
xfeed_22096 1 0 decap_w0
xfeed_22095 1 0 decap_w0
xfeed_22094 1 0 decap_w0
xfeed_22093 1 0 decap_w0
xfeed_22092 1 0 decap_w0
xfeed_22091 1 0 decap_w0
xfeed_22090 1 0 decap_w0
xfeed_21569 1 0 decap_w0
xfeed_21568 1 0 decap_w0
xfeed_21567 1 0 decap_w0
xfeed_21566 1 0 decap_w0
xfeed_21565 1 0 decap_w0
xfeed_21564 1 0 decap_w0
xfeed_21563 1 0 decap_w0
xfeed_21562 1 0 decap_w0
xfeed_21561 1 0 decap_w0
xfeed_21560 1 0 decap_w0
xfeed_16092 1 0 decap_w0
xfeed_16091 1 0 decap_w0
xfeed_16090 1 0 decap_w0
xfeed_11253 1 0 decap_w0
xfeed_11252 1 0 decap_w0
xfeed_11251 1 0 decap_w0
xfeed_11250 1 0 decap_w0
xfeed_8829 1 0 decap_w0
xfeed_8828 1 0 decap_w0
xfeed_8827 1 0 decap_w0
xfeed_8826 1 0 decap_w0
xfeed_8825 1 0 decap_w0
xspare_feed_14 1 0 tie
xspare_feed_15 1 0 tie
xspare_feed_16 1 0 tie
xspare_feed_17 1 0 tie
xspare_feed_18 1 0 tie
xspare_feed_19 1 0 tie
xfeed_19879 1 0 decap_w0
xfeed_19878 1 0 decap_w0
xfeed_19877 1 0 decap_w0
xfeed_19876 1 0 decap_w0
xfeed_19875 1 0 decap_w0
xfeed_19874 1 0 decap_w0
xfeed_19873 1 0 decap_w0
xfeed_19872 1 0 decap_w0
xfeed_19871 1 0 decap_w0
xfeed_19870 1 0 decap_w0
xfeed_16099 1 0 decap_w0
xfeed_16098 1 0 decap_w0
xfeed_16097 1 0 decap_w0
xfeed_16096 1 0 decap_w0
xfeed_16095 1 0 decap_w0
xfeed_16094 1 0 decap_w0
xfeed_16093 1 0 decap_w0
xfeed_15569 1 0 decap_w0
xfeed_15568 1 0 decap_w0
xfeed_15567 1 0 decap_w0
xfeed_15566 1 0 decap_w0
xfeed_15565 1 0 decap_w0
xfeed_15564 1 0 decap_w0
xfeed_15563 1 0 decap_w0
xfeed_15562 1 0 decap_w0
xfeed_15561 1 0 decap_w0
xfeed_15560 1 0 decap_w0
xfeed_11259 1 0 decap_w0
xfeed_11258 1 0 decap_w0
xfeed_11257 1 0 decap_w0
xfeed_11256 1 0 decap_w0
xfeed_11255 1 0 decap_w0
xfeed_11254 1 0 decap_w0
xfeed_10729 1 0 decap_w0
xfeed_10728 1 0 decap_w0
xfeed_10727 1 0 decap_w0
xfeed_10726 1 0 decap_w0
xfeed_10725 1 0 decap_w0
xfeed_10724 1 0 decap_w0
xfeed_10723 1 0 decap_w0
xfeed_10722 1 0 decap_w0
xfeed_10721 1 0 decap_w0
xfeed_10720 1 0 decap_w0
xfeed_9369 1 0 decap_w0
xfeed_9368 1 0 decap_w0
xfeed_9367 1 0 decap_w0
xfeed_9366 1 0 decap_w0
xfeed_9365 1 0 decap_w0
xfeed_9364 1 0 decap_w0
xfeed_9363 1 0 decap_w0
xfeed_9362 1 0 decap_w0
xfeed_9361 1 0 decap_w0
xfeed_9360 1 0 decap_w0
xfeed_8831 1 0 decap_w0
xfeed_8830 1 0 decap_w0
xfeed_5059 1 0 decap_w0
xfeed_5058 1 0 decap_w0
xfeed_5057 1 0 decap_w0
xfeed_5056 1 0 decap_w0
xfeed_5055 1 0 decap_w0
xfeed_5054 1 0 decap_w0
xfeed_5053 1 0 decap_w0
xfeed_5052 1 0 decap_w0
xfeed_5051 1 0 decap_w0
xfeed_5050 1 0 decap_w0
xfeed_4529 1 0 decap_w0
xfeed_4528 1 0 decap_w0
xfeed_4527 1 0 decap_w0
xfeed_4526 1 0 decap_w0
xfeed_4525 1 0 decap_w0
xfeed_4524 1 0 decap_w0
xfeed_4523 1 0 decap_w0
xfeed_4522 1 0 decap_w0
xfeed_4521 1 0 decap_w0
xfeed_4520 1 0 decap_w0
xspare_feed_20 1 0 tie
xfeed_31889 1 0 decap_w0
xfeed_31888 1 0 decap_w0
xfeed_31887 1 0 decap_w0
xfeed_31886 1 0 decap_w0
xfeed_31885 1 0 decap_w0
xfeed_31884 1 0 decap_w0
xfeed_31883 1 0 decap_w0
xfeed_31882 1 0 decap_w0
xfeed_31881 1 0 decap_w0
xfeed_31880 1 0 decap_w0
xfeed_27029 1 0 decap_w0
xfeed_27028 1 0 decap_w0
xfeed_27027 1 0 decap_w0
xfeed_27026 1 0 decap_w0
xfeed_27025 1 0 decap_w0
xfeed_27024 1 0 decap_w0
xfeed_27023 1 0 decap_w0
xfeed_27022 1 0 decap_w0
xfeed_27021 1 0 decap_w0
xfeed_27020 1 0 decap_w0
xfeed_25887 1 0 decap_w0
xfeed_25886 1 0 decap_w0
xfeed_25885 1 0 decap_w0
xfeed_25884 1 0 decap_w0
xfeed_25883 1 0 decap_w0
xfeed_25882 1 0 decap_w0
xfeed_25881 1 0 decap_w0
xfeed_25880 1 0 decap_w0
xfeed_21579 1 0 decap_w0
xfeed_21578 1 0 decap_w0
xfeed_21577 1 0 decap_w0
xfeed_21576 1 0 decap_w0
xfeed_21575 1 0 decap_w0
xfeed_21574 1 0 decap_w0
xfeed_21573 1 0 decap_w0
xfeed_21572 1 0 decap_w0
xfeed_21571 1 0 decap_w0
xfeed_21570 1 0 decap_w0
xfeed_11260 1 0 decap_w0
xfeed_8839 1 0 decap_w0
xfeed_8838 1 0 decap_w0
xfeed_8837 1 0 decap_w0
xfeed_8836 1 0 decap_w0
xfeed_8835 1 0 decap_w0
xfeed_8834 1 0 decap_w0
xfeed_8833 1 0 decap_w0
xfeed_8832 1 0 decap_w0
xspare_feed_21 1 0 tie
xspare_feed_22 1 0 tie
xspare_feed_23 1 0 tie
xspare_feed_24 1 0 tie
xspare_feed_25 1 0 tie
xspare_feed_26 1 0 tie
xspare_feed_27 1 0 tie
xspare_feed_28 1 0 tie
xspare_feed_29 1 0 tie
xfeed_25889 1 0 decap_w0
xfeed_25888 1 0 decap_w0
xfeed_19889 1 0 decap_w0
xfeed_19888 1 0 decap_w0
xfeed_19887 1 0 decap_w0
xfeed_19886 1 0 decap_w0
xfeed_19885 1 0 decap_w0
xfeed_19884 1 0 decap_w0
xfeed_19883 1 0 decap_w0
xfeed_19882 1 0 decap_w0
xfeed_19881 1 0 decap_w0
xfeed_19880 1 0 decap_w0
xfeed_15579 1 0 decap_w0
xfeed_15578 1 0 decap_w0
xfeed_15577 1 0 decap_w0
xfeed_15576 1 0 decap_w0
xfeed_15575 1 0 decap_w0
xfeed_15574 1 0 decap_w0
xfeed_15573 1 0 decap_w0
xfeed_15572 1 0 decap_w0
xfeed_15571 1 0 decap_w0
xfeed_15570 1 0 decap_w0
xfeed_11269 1 0 decap_w0
xfeed_11268 1 0 decap_w0
xfeed_11267 1 0 decap_w0
xfeed_11266 1 0 decap_w0
xfeed_11265 1 0 decap_w0
xfeed_11264 1 0 decap_w0
xfeed_11263 1 0 decap_w0
xfeed_11262 1 0 decap_w0
xfeed_11261 1 0 decap_w0
xfeed_10739 1 0 decap_w0
xfeed_10738 1 0 decap_w0
xfeed_10737 1 0 decap_w0
xfeed_10736 1 0 decap_w0
xfeed_10735 1 0 decap_w0
xfeed_10734 1 0 decap_w0
xfeed_10733 1 0 decap_w0
xfeed_10732 1 0 decap_w0
xfeed_10731 1 0 decap_w0
xfeed_10730 1 0 decap_w0
xfeed_9377 1 0 decap_w0
xfeed_9376 1 0 decap_w0
xfeed_9375 1 0 decap_w0
xfeed_9374 1 0 decap_w0
xfeed_9373 1 0 decap_w0
xfeed_9372 1 0 decap_w0
xfeed_9371 1 0 decap_w0
xfeed_9370 1 0 decap_w0
xfeed_5069 1 0 decap_w0
xfeed_5068 1 0 decap_w0
xfeed_5067 1 0 decap_w0
xfeed_5066 1 0 decap_w0
xfeed_5065 1 0 decap_w0
xfeed_5064 1 0 decap_w0
xfeed_5063 1 0 decap_w0
xfeed_5062 1 0 decap_w0
xfeed_5061 1 0 decap_w0
xfeed_5060 1 0 decap_w0
xfeed_4538 1 0 decap_w0
xfeed_4537 1 0 decap_w0
xfeed_4536 1 0 decap_w0
xfeed_4535 1 0 decap_w0
xfeed_4534 1 0 decap_w0
xfeed_4533 1 0 decap_w0
xfeed_4532 1 0 decap_w0
xfeed_4531 1 0 decap_w0
xfeed_4530 1 0 decap_w0
xsubckt_20_nexor2_x0 1 0 127 21 126 nexor2_x0
xspare_feed_0 1 0 tie
xspare_feed_1 1 0 tie
xspare_feed_2 1 0 tie
xspare_feed_3 1 0 tie
xspare_feed_4 1 0 tie
xspare_feed_5 1 0 tie
xspare_feed_6 1 0 tie
xspare_feed_7 1 0 tie
xspare_feed_8 1 0 tie
xspare_feed_9 1 0 tie
xfeed_31899 1 0 decap_w0
xfeed_31898 1 0 decap_w0
xfeed_31897 1 0 decap_w0
xfeed_31896 1 0 decap_w0
xfeed_31895 1 0 decap_w0
xfeed_31894 1 0 decap_w0
xfeed_31893 1 0 decap_w0
xfeed_31892 1 0 decap_w0
xfeed_31891 1 0 decap_w0
xfeed_31890 1 0 decap_w0
xfeed_27039 1 0 decap_w0
xfeed_27038 1 0 decap_w0
xfeed_27037 1 0 decap_w0
xfeed_27036 1 0 decap_w0
xfeed_27035 1 0 decap_w0
xfeed_27034 1 0 decap_w0
xfeed_27033 1 0 decap_w0
xfeed_27032 1 0 decap_w0
xfeed_27031 1 0 decap_w0
xfeed_27030 1 0 decap_w0
xfeed_26509 1 0 decap_w0
xfeed_26508 1 0 decap_w0
xfeed_26507 1 0 decap_w0
xfeed_26506 1 0 decap_w0
xfeed_26505 1 0 decap_w0
xfeed_26504 1 0 decap_w0
xfeed_26503 1 0 decap_w0
xfeed_26502 1 0 decap_w0
xfeed_26501 1 0 decap_w0
xfeed_26500 1 0 decap_w0
xfeed_25894 1 0 decap_w0
xfeed_25893 1 0 decap_w0
xfeed_25892 1 0 decap_w0
xfeed_25891 1 0 decap_w0
xfeed_25890 1 0 decap_w0
xfeed_21589 1 0 decap_w0
xfeed_21588 1 0 decap_w0
xfeed_21587 1 0 decap_w0
xfeed_21586 1 0 decap_w0
xfeed_21585 1 0 decap_w0
xfeed_21584 1 0 decap_w0
xfeed_21583 1 0 decap_w0
xfeed_21582 1 0 decap_w0
xfeed_21581 1 0 decap_w0
xfeed_21580 1 0 decap_w0
xfeed_9379 1 0 decap_w0
xfeed_9378 1 0 decap_w0
xfeed_8849 1 0 decap_w0
xfeed_8848 1 0 decap_w0
xfeed_8847 1 0 decap_w0
xfeed_8846 1 0 decap_w0
xfeed_8845 1 0 decap_w0
xfeed_8844 1 0 decap_w0
xfeed_8843 1 0 decap_w0
xfeed_8842 1 0 decap_w0
xfeed_8841 1 0 decap_w0
xfeed_8840 1 0 decap_w0
xfeed_4539 1 0 decap_w0
xspare_feed_39 1 0 tie
xspare_feed_38 1 0 tie
xspare_feed_37 1 0 tie
xspare_feed_36 1 0 tie
xspare_feed_35 1 0 tie
xspare_feed_34 1 0 tie
xspare_feed_33 1 0 tie
xspare_feed_32 1 0 tie
xspare_feed_31 1 0 tie
xspare_feed_30 1 0 tie
xsubckt_11_nexor2_x0 1 0 51 38 132 nexor2_x0
xfeed_25899 1 0 decap_w0
xfeed_25898 1 0 decap_w0
xfeed_25897 1 0 decap_w0
xfeed_25896 1 0 decap_w0
xfeed_25895 1 0 decap_w0
xfeed_19899 1 0 decap_w0
xfeed_19898 1 0 decap_w0
xfeed_19897 1 0 decap_w0
xfeed_19896 1 0 decap_w0
xfeed_19895 1 0 decap_w0
xfeed_19894 1 0 decap_w0
xfeed_19893 1 0 decap_w0
xfeed_19892 1 0 decap_w0
xfeed_19891 1 0 decap_w0
xfeed_19890 1 0 decap_w0
xfeed_15589 1 0 decap_w0
xfeed_15588 1 0 decap_w0
xfeed_15587 1 0 decap_w0
xfeed_15586 1 0 decap_w0
xfeed_15585 1 0 decap_w0
xfeed_15584 1 0 decap_w0
xfeed_15583 1 0 decap_w0
xfeed_15582 1 0 decap_w0
xfeed_15581 1 0 decap_w0
xfeed_15580 1 0 decap_w0
xfeed_11279 1 0 decap_w0
xfeed_11278 1 0 decap_w0
xfeed_11277 1 0 decap_w0
xfeed_11276 1 0 decap_w0
xfeed_11275 1 0 decap_w0
xfeed_11274 1 0 decap_w0
xfeed_11273 1 0 decap_w0
xfeed_11272 1 0 decap_w0
xfeed_11271 1 0 decap_w0
xfeed_11270 1 0 decap_w0
xfeed_10749 1 0 decap_w0
xfeed_10748 1 0 decap_w0
xfeed_10747 1 0 decap_w0
xfeed_10746 1 0 decap_w0
xfeed_10745 1 0 decap_w0
xfeed_10744 1 0 decap_w0
xfeed_10743 1 0 decap_w0
xfeed_10742 1 0 decap_w0
xfeed_10741 1 0 decap_w0
xfeed_10740 1 0 decap_w0
xfeed_9384 1 0 decap_w0
xfeed_9383 1 0 decap_w0
xfeed_9382 1 0 decap_w0
xfeed_9381 1 0 decap_w0
xfeed_9380 1 0 decap_w0
xfeed_5079 1 0 decap_w0
xfeed_5078 1 0 decap_w0
xfeed_5077 1 0 decap_w0
xfeed_5076 1 0 decap_w0
xfeed_5075 1 0 decap_w0
xfeed_5074 1 0 decap_w0
xfeed_5073 1 0 decap_w0
xfeed_5072 1 0 decap_w0
xfeed_5071 1 0 decap_w0
xfeed_5070 1 0 decap_w0
xfeed_4545 1 0 decap_w0
xfeed_4544 1 0 decap_w0
xfeed_4543 1 0 decap_w0
xfeed_4542 1 0 decap_w0
xfeed_4541 1 0 decap_w0
xfeed_4540 1 0 decap_w0
xfeed_27049 1 0 decap_w0
xfeed_27048 1 0 decap_w0
xfeed_27047 1 0 decap_w0
xfeed_27046 1 0 decap_w0
xfeed_27045 1 0 decap_w0
xfeed_27044 1 0 decap_w0
xfeed_27043 1 0 decap_w0
xfeed_27042 1 0 decap_w0
xfeed_27041 1 0 decap_w0
xfeed_27040 1 0 decap_w0
xfeed_26519 1 0 decap_w0
xfeed_26518 1 0 decap_w0
xfeed_26517 1 0 decap_w0
xfeed_26516 1 0 decap_w0
xfeed_26515 1 0 tie
xfeed_26514 1 0 decap_w0
xfeed_26513 1 0 decap_w0
xfeed_26512 1 0 decap_w0
xfeed_26511 1 0 decap_w0
xfeed_26510 1 0 decap_w0
xfeed_22209 1 0 decap_w0
xfeed_22208 1 0 decap_w0
xfeed_22207 1 0 decap_w0
xfeed_22206 1 0 decap_w0
xfeed_22205 1 0 decap_w0
xfeed_22204 1 0 decap_w0
xfeed_22203 1 0 decap_w0
xfeed_22202 1 0 decap_w0
xfeed_22201 1 0 decap_w0
xfeed_22200 1 0 decap_w0
xfeed_21599 1 0 decap_w0
xfeed_21598 1 0 decap_w0
xfeed_21597 1 0 decap_w0
xfeed_21596 1 0 decap_w0
xfeed_21595 1 0 decap_w0
xfeed_21594 1 0 decap_w0
xfeed_21593 1 0 decap_w0
xfeed_21592 1 0 decap_w0
xfeed_21591 1 0 decap_w0
xfeed_21590 1 0 decap_w0
xfeed_16209 1 0 decap_w0
xfeed_16208 1 0 decap_w0
xfeed_16207 1 0 decap_w0
xfeed_16206 1 0 decap_w0
xfeed_16205 1 0 decap_w0
xfeed_16204 1 0 decap_w0
xfeed_16203 1 0 decap_w0
xfeed_16202 1 0 decap_w0
xfeed_16201 1 0 decap_w0
xfeed_16200 1 0 decap_w0
xfeed_9389 1 0 decap_w0
xfeed_9388 1 0 decap_w0
xfeed_9387 1 0 decap_w0
xfeed_9386 1 0 decap_w0
xfeed_9385 1 0 decap_w0
xfeed_8859 1 0 decap_w0
xfeed_8858 1 0 decap_w0
xfeed_8857 1 0 decap_w0
xfeed_8856 1 0 decap_w0
xfeed_8855 1 0 decap_w0
xfeed_8854 1 0 decap_w0
xfeed_8853 1 0 decap_w0
xfeed_8852 1 0 decap_w0
xfeed_8851 1 0 decap_w0
xfeed_8850 1 0 decap_w0
xfeed_4549 1 0 decap_w0
xfeed_4548 1 0 decap_w0
xfeed_4547 1 0 decap_w0
xfeed_4546 1 0 decap_w0
xspare_feed_49 1 0 tie
xspare_feed_48 1 0 tie
xspare_feed_47 1 0 tie
xspare_feed_46 1 0 tie
xspare_feed_45 1 0 tie
xspare_feed_44 1 0 tie
xspare_feed_43 1 0 tie
xspare_feed_42 1 0 tie
xspare_feed_41 1 0 tie
xspare_feed_40 1 0 tie
xfeed_15599 1 0 decap_w0
xfeed_15598 1 0 decap_w0
xfeed_15597 1 0 decap_w0
xfeed_15596 1 0 decap_w0
xfeed_15595 1 0 decap_w0
xfeed_15594 1 0 decap_w0
xfeed_15593 1 0 decap_w0
xfeed_15592 1 0 decap_w0
xfeed_15591 1 0 decap_w0
xfeed_15590 1 0 decap_w0
xfeed_11289 1 0 decap_w0
xfeed_11288 1 0 decap_w0
xfeed_11287 1 0 decap_w0
xfeed_11286 1 0 decap_w0
xfeed_11285 1 0 decap_w0
xfeed_11284 1 0 decap_w0
xfeed_11283 1 0 decap_w0
xfeed_11282 1 0 decap_w0
xfeed_11281 1 0 decap_w0
xfeed_11280 1 0 decap_w0
xfeed_10759 1 0 decap_w0
xfeed_10758 1 0 decap_w0
xfeed_10757 1 0 decap_w0
xfeed_10756 1 0 decap_w0
xfeed_10755 1 0 decap_w0
xfeed_10754 1 0 decap_w0
xfeed_10753 1 0 decap_w0
xfeed_10752 1 0 decap_w0
xfeed_10751 1 0 decap_w0
xfeed_10750 1 0 decap_w0
xfeed_9391 1 0 decap_w0
xfeed_9390 1 0 decap_w0
xfeed_5089 1 0 decap_w0
xfeed_5088 1 0 decap_w0
xfeed_5087 1 0 decap_w0
xfeed_5086 1 0 decap_w0
xfeed_5085 1 0 decap_w0
xfeed_5084 1 0 decap_w0
xfeed_5083 1 0 decap_w0
xfeed_5082 1 0 decap_w0
xfeed_5081 1 0 decap_w0
xfeed_5080 1 0 decap_w0
xfeed_4552 1 0 decap_w0
xfeed_4551 1 0 decap_w0
xfeed_4550 1 0 decap_w0
xsubckt_80_nexor2_x0 1 0 48 35 154 nexor2_x0
xfeed_27059 1 0 decap_w0
xfeed_27058 1 0 decap_w0
xfeed_27057 1 0 decap_w0
xfeed_27056 1 0 decap_w0
xfeed_27055 1 0 decap_w0
xfeed_27054 1 0 decap_w0
xfeed_27053 1 0 decap_w0
xfeed_27052 1 0 decap_w0
xfeed_27051 1 0 decap_w0
xfeed_27050 1 0 decap_w0
xfeed_26529 1 0 decap_w0
xfeed_26528 1 0 decap_w0
xfeed_26527 1 0 decap_w0
xfeed_26526 1 0 decap_w0
xfeed_26525 1 0 decap_w0
xfeed_26524 1 0 decap_w0
xfeed_26523 1 0 decap_w0
xfeed_26522 1 0 decap_w0
xfeed_26521 1 0 decap_w0
xfeed_26520 1 0 decap_w0
xfeed_22219 1 0 decap_w0
xfeed_22218 1 0 decap_w0
xfeed_22217 1 0 decap_w0
xfeed_22216 1 0 decap_w0
xfeed_22215 1 0 decap_w0
xfeed_22214 1 0 decap_w0
xfeed_22213 1 0 decap_w0
xfeed_22212 1 0 decap_w0
xfeed_22211 1 0 decap_w0
xfeed_22210 1 0 decap_w0
xfeed_16218 1 0 decap_w0
xfeed_16217 1 0 decap_w0
xfeed_16216 1 0 decap_w0
xfeed_16215 1 0 decap_w0
xfeed_16214 1 0 decap_w0
xfeed_16213 1 0 decap_w0
xfeed_16212 1 0 decap_w0
xfeed_16211 1 0 decap_w0
xfeed_16210 1 0 decap_w0
xfeed_9399 1 0 decap_w0
xfeed_9398 1 0 decap_w0
xfeed_9397 1 0 decap_w0
xfeed_9396 1 0 decap_w0
xfeed_9395 1 0 decap_w0
xfeed_9394 1 0 decap_w0
xfeed_9393 1 0 decap_w0
xfeed_9392 1 0 decap_w0
xfeed_8869 1 0 decap_w0
xfeed_8868 1 0 decap_w0
xfeed_8867 1 0 decap_w0
xfeed_8866 1 0 decap_w0
xfeed_8865 1 0 decap_w0
xfeed_8864 1 0 decap_w0
xfeed_8863 1 0 decap_w0
xfeed_8862 1 0 decap_w0
xfeed_8861 1 0 decap_w0
xfeed_8860 1 0 decap_w0
xfeed_4559 1 0 decap_w0
xfeed_4558 1 0 decap_w0
xfeed_4557 1 0 decap_w0
xfeed_4556 1 0 decap_w0
xfeed_4555 1 0 decap_w0
xfeed_4554 1 0 decap_w0
xfeed_4553 1 0 decap_w0
xspare_feed_59 1 0 tie
xspare_feed_58 1 0 tie
xspare_feed_57 1 0 tie
xspare_feed_56 1 0 tie
xspare_feed_55 1 0 tie
xspare_feed_54 1 0 tie
xspare_feed_53 1 0 tie
xspare_feed_52 1 0 tie
xspare_feed_51 1 0 tie
xspare_feed_50 1 0 tie
xsubckt_62_nexor2_x0 1 0 168 172 167 nexor2_x0
xfeed_16219 1 0 decap_w0
xfeed_11299 1 0 decap_w0
xfeed_11298 1 0 decap_w0
xfeed_11297 1 0 decap_w0
xfeed_11296 1 0 decap_w0
xfeed_11295 1 0 decap_w0
xfeed_11294 1 0 decap_w0
xfeed_11293 1 0 decap_w0
xfeed_11292 1 0 decap_w0
xfeed_11291 1 0 decap_w0
xfeed_11290 1 0 decap_w0
xfeed_10769 1 0 decap_w0
xfeed_10768 1 0 decap_w0
xfeed_10767 1 0 decap_w0
xfeed_10766 1 0 decap_w0
xfeed_10765 1 0 decap_w0
xfeed_10764 1 0 decap_w0
xfeed_10763 1 0 decap_w0
xfeed_10762 1 0 decap_w0
xfeed_10761 1 0 decap_w0
xfeed_10760 1 0 decap_w0
xfeed_5098 1 0 decap_w0
xfeed_5097 1 0 decap_w0
xfeed_5096 1 0 decap_w0
xfeed_5095 1 0 decap_w0
xfeed_5094 1 0 decap_w0
xfeed_5093 1 0 decap_w0
xfeed_5092 1 0 decap_w0
xfeed_5091 1 0 decap_w0
xfeed_5090 1 0 decap_w0
xsubckt_53_nexor2_x0 1 0 174 126 4 nexor2_x0
xsubckt_44_nexor2_x0 1 0 179 12 9 nexor2_x0
xsubckt_5_nexor2_x0 1 0 136 3 135 nexor2_x0
xfeed_27069 1 0 decap_w0
xfeed_27068 1 0 decap_w0
xfeed_27067 1 0 decap_w0
xfeed_27066 1 0 decap_w0
xfeed_27065 1 0 decap_w0
xfeed_27064 1 0 decap_w0
xfeed_27063 1 0 decap_w0
xfeed_27062 1 0 decap_w0
xfeed_27061 1 0 decap_w0
xfeed_27060 1 0 decap_w0
xfeed_26539 1 0 decap_w0
xfeed_26538 1 0 decap_w0
xfeed_26537 1 0 decap_w0
xfeed_26536 1 0 decap_w0
xfeed_26535 1 0 decap_w0
xfeed_26534 1 0 decap_w0
xfeed_26533 1 0 decap_w0
xfeed_26532 1 0 decap_w0
xfeed_26531 1 0 decap_w0
xfeed_26530 1 0 decap_w0
xfeed_22229 1 0 decap_w0
xfeed_22228 1 0 decap_w0
xfeed_22227 1 0 decap_w0
xfeed_22226 1 0 decap_w0
xfeed_22225 1 0 decap_w0
xfeed_22224 1 0 decap_w0
xfeed_22223 1 0 decap_w0
xfeed_22222 1 0 decap_w0
xfeed_22221 1 0 decap_w0
xfeed_22220 1 0 decap_w0
xfeed_16225 1 0 decap_w0
xfeed_16224 1 0 decap_w0
xfeed_16223 1 0 decap_w0
xfeed_16222 1 0 decap_w0
xfeed_16221 1 0 decap_w0
xfeed_16220 1 0 decap_w0
xfeed_8879 1 0 decap_w0
xfeed_8878 1 0 decap_w0
xfeed_8877 1 0 decap_w0
xfeed_8876 1 0 decap_w0
xfeed_8875 1 0 decap_w0
xfeed_8874 1 0 decap_w0
xfeed_8873 1 0 decap_w0
xfeed_8872 1 0 decap_w0
xfeed_8871 1 0 decap_w0
xfeed_8870 1 0 decap_w0
xfeed_5099 1 0 decap_w0
xfeed_4569 1 0 decap_w0
xfeed_4568 1 0 decap_w0
xfeed_4567 1 0 decap_w0
xfeed_4566 1 0 decap_w0
xfeed_4565 1 0 decap_w0
xfeed_4564 1 0 decap_w0
xfeed_4563 1 0 decap_w0
xfeed_4562 1 0 decap_w0
xfeed_4561 1 0 decap_w0
xfeed_4560 1 0 decap_w0
xspare_feed_69 1 0 tie
xspare_feed_68 1 0 tie
xspare_feed_67 1 0 tie
xspare_feed_66 1 0 tie
xspare_feed_65 1 0 tie
xspare_feed_64 1 0 tie
xspare_feed_63 1 0 tie
xspare_feed_62 1 0 tie
xspare_feed_61 1 0 tie
xspare_feed_60 1 0 tie
xsubckt_35_nexor2_x0 1 0 116 118 115 nexor2_x0
xfeed_16229 1 0 decap_w0
xfeed_16228 1 0 decap_w0
xfeed_16227 1 0 decap_w0
xfeed_16226 1 0 decap_w0
xfeed_10779 1 0 decap_w0
xfeed_10778 1 0 decap_w0
xfeed_10777 1 0 decap_w0
xfeed_10776 1 0 decap_w0
xfeed_10775 1 0 decap_w0
xfeed_10774 1 0 decap_w0
xfeed_10773 1 0 decap_w0
xfeed_10772 1 0 decap_w0
xfeed_10771 1 0 decap_w0
xfeed_10770 1 0 decap_w0
xsubckt_26_nexor2_x0 1 0 36 58 122 nexor2_x0
xfeed_27079 1 0 decap_w0
xfeed_27078 1 0 decap_w0
xfeed_27077 1 0 decap_w0
xfeed_27076 1 0 decap_w0
xfeed_27075 1 0 decap_w0
xfeed_27074 1 0 decap_w0
xfeed_27073 1 0 decap_w0
xfeed_27072 1 0 decap_w0
xfeed_27071 1 0 decap_w0
xfeed_27070 1 0 decap_w0
xfeed_26549 1 0 decap_w0
xfeed_26548 1 0 decap_w0
xfeed_26547 1 0 decap_w0
xfeed_26546 1 0 decap_w0
xfeed_26545 1 0 decap_w0
xfeed_26544 1 0 decap_w0
xfeed_26543 1 0 decap_w0
xfeed_26542 1 0 decap_w0
xfeed_26541 1 0 decap_w0
xfeed_26540 1 0 decap_w0
xfeed_22239 1 0 decap_w0
xfeed_22238 1 0 decap_w0
xfeed_22237 1 0 decap_w0
xfeed_22236 1 0 decap_w0
xfeed_22235 1 0 decap_w0
xfeed_22234 1 0 decap_w0
xfeed_22233 1 0 decap_w0
xfeed_22232 1 0 decap_w0
xfeed_22231 1 0 decap_w0
xfeed_22230 1 0 decap_w0
xfeed_21709 1 0 decap_w0
xfeed_21708 1 0 decap_w0
xfeed_21707 1 0 decap_w0
xfeed_21706 1 0 decap_w0
xfeed_21705 1 0 decap_w0
xfeed_21704 1 0 decap_w0
xfeed_21703 1 0 decap_w0
xfeed_21702 1 0 decap_w0
xfeed_21701 1 0 decap_w0
xfeed_21700 1 0 decap_w0
xfeed_16232 1 0 decap_w0
xfeed_16231 1 0 decap_w0
xfeed_16230 1 0 decap_w0
xfeed_8889 1 0 decap_w0
xfeed_8888 1 0 decap_w0
xfeed_8887 1 0 decap_w0
xfeed_8886 1 0 decap_w0
xfeed_8885 1 0 decap_w0
xfeed_8884 1 0 decap_w0
xfeed_8883 1 0 decap_w0
xfeed_8882 1 0 decap_w0
xfeed_8881 1 0 decap_w0
xfeed_8880 1 0 decap_w0
xfeed_4579 1 0 decap_w0
xfeed_4578 1 0 decap_w0
xfeed_4577 1 0 decap_w0
xfeed_4576 1 0 decap_w0
xfeed_4575 1 0 decap_w0
xfeed_4574 1 0 decap_w0
xfeed_4573 1 0 decap_w0
xfeed_4572 1 0 decap_w0
xfeed_4571 1 0 decap_w0
xfeed_4570 1 0 decap_w0
xspare_feed_79 1 0 tie
xspare_feed_78 1 0 tie
xspare_feed_77 1 0 tie
xspare_feed_76 1 0 tie
xspare_feed_75 1 0 tie
xspare_feed_74 1 0 tie
xspare_feed_73 1 0 tie
xspare_feed_72 1 0 tie
xspare_feed_71 1 0 tie
xspare_feed_70 1 0 tie
xsubckt_17_nexor2_x0 1 0 52 64 128 nexor2_x0
xfeed_16239 1 0 decap_w0
xfeed_16238 1 0 decap_w0
xfeed_16237 1 0 decap_w0
xfeed_16236 1 0 decap_w0
xfeed_16235 1 0 decap_w0
xfeed_16234 1 0 decap_w0
xfeed_16233 1 0 decap_w0
xfeed_15709 1 0 decap_w0
xfeed_15708 1 0 decap_w0
xfeed_15707 1 0 decap_w0
xfeed_15706 1 0 decap_w0
xfeed_15705 1 0 decap_w0
xfeed_15704 1 0 decap_w0
xfeed_15703 1 0 decap_w0
xfeed_15702 1 0 decap_w0
xfeed_15701 1 0 decap_w0
xfeed_15700 1 0 decap_w0
xfeed_10789 1 0 decap_w0
xfeed_10788 1 0 decap_w0
xfeed_10787 1 0 decap_w0
xfeed_10786 1 0 decap_w0
xfeed_10785 1 0 decap_w0
xfeed_10784 1 0 decap_w0
xfeed_10783 1 0 decap_w0
xfeed_10782 1 0 decap_w0
xfeed_10781 1 0 decap_w0
xfeed_10780 1 0 decap_w0
xfeed_9509 1 0 decap_w0
xfeed_9508 1 0 decap_w0
xfeed_9507 1 0 decap_w0
xfeed_9506 1 0 decap_w0
xfeed_9505 1 0 decap_w0
xfeed_9504 1 0 decap_w0
xfeed_9503 1 0 decap_w0
xfeed_9502 1 0 decap_w0
xfeed_9501 1 0 decap_w0
xfeed_9500 1 0 decap_w0
xfeed_27089 1 0 decap_w0
xfeed_27088 1 0 decap_w0
xfeed_27087 1 0 decap_w0
xfeed_27086 1 0 decap_w0
xfeed_27085 1 0 decap_w0
xfeed_27084 1 0 decap_w0
xfeed_27083 1 0 decap_w0
xfeed_27082 1 0 decap_w0
xfeed_27081 1 0 decap_w0
xfeed_27080 1 0 decap_w0
xfeed_26559 1 0 decap_w0
xfeed_26558 1 0 decap_w0
xfeed_26557 1 0 decap_w0
xfeed_26556 1 0 decap_w0
xfeed_26555 1 0 decap_w0
xfeed_26554 1 0 decap_w0
xfeed_26553 1 0 decap_w0
xfeed_26552 1 0 decap_w0
xfeed_26551 1 0 decap_w0
xfeed_26550 1 0 decap_w0
xfeed_22249 1 0 decap_w0
xfeed_22248 1 0 decap_w0
xfeed_22247 1 0 decap_w0
xfeed_22246 1 0 decap_w0
xfeed_22245 1 0 decap_w0
xfeed_22244 1 0 decap_w0
xfeed_22243 1 0 decap_w0
xfeed_22242 1 0 decap_w0
xfeed_22241 1 0 decap_w0
xfeed_22240 1 0 decap_w0
xfeed_21719 1 0 decap_w0
xfeed_21718 1 0 decap_w0
xfeed_21717 1 0 decap_w0
xfeed_21716 1 0 decap_w0
xfeed_21715 1 0 decap_w0
xfeed_21714 1 0 decap_w0
xfeed_21713 1 0 decap_w0
xfeed_21712 1 0 decap_w0
xfeed_21711 1 0 decap_w0
xfeed_21710 1 0 decap_w0
xfeed_11400 1 0 decap_w0
xfeed_8899 1 0 decap_w0
xfeed_8898 1 0 decap_w0
xfeed_8897 1 0 decap_w0
xfeed_8896 1 0 decap_w0
xfeed_8895 1 0 decap_w0
xfeed_8894 1 0 decap_w0
xfeed_8893 1 0 decap_w0
xfeed_8892 1 0 decap_w0
xfeed_8891 1 0 decap_w0
xfeed_8890 1 0 decap_w0
xfeed_4589 1 0 decap_w0
xfeed_4588 1 0 decap_w0
xfeed_4587 1 0 decap_w0
xfeed_4586 1 0 decap_w0
xfeed_4585 1 0 decap_w0
xfeed_4584 1 0 decap_w0
xfeed_4583 1 0 decap_w0
xfeed_4582 1 0 decap_w0
xfeed_4581 1 0 decap_w0
xfeed_4580 1 0 decap_w0
xspare_feed_89 1 0 tie
xspare_feed_88 1 0 tie
xspare_feed_87 1 0 decap_w0
xspare_feed_86 1 0 tie
xspare_feed_85 1 0 tie
xspare_feed_84 1 0 decap_w0
xspare_feed_83 1 0 tie
xspare_feed_82 1 0 tie
xspare_feed_81 1 0 tie
xspare_feed_80 1 0 tie
xsubckt_86_nexor2_x0 1 0 151 173 149 nexor2_x0
xsubckt_95_nexor2_x0 1 0 143 12 11 nexor2_x0
xfeed_16249 1 0 decap_w0
xfeed_16248 1 0 decap_w0
xfeed_16247 1 0 decap_w0
xfeed_16246 1 0 decap_w0
xfeed_16245 1 0 decap_w0
xfeed_16244 1 0 decap_w0
xfeed_16243 1 0 decap_w0
xfeed_16242 1 0 decap_w0
xfeed_16241 1 0 tie
xfeed_16240 1 0 decap_w0
xfeed_15719 1 0 decap_w0
xfeed_15718 1 0 decap_w0
xfeed_15717 1 0 decap_w0
xfeed_15716 1 0 decap_w0
xfeed_15715 1 0 decap_w0
xfeed_15714 1 0 decap_w0
xfeed_15713 1 0 decap_w0
xfeed_15712 1 0 decap_w0
xfeed_15711 1 0 decap_w0
xfeed_15710 1 0 decap_w0
xfeed_11409 1 0 decap_w0
xfeed_11408 1 0 decap_w0
xfeed_11407 1 0 decap_w0
xfeed_11406 1 0 decap_w0
xfeed_11405 1 0 decap_w0
xfeed_11404 1 0 decap_w0
xfeed_11403 1 0 decap_w0
xfeed_11402 1 0 decap_w0
xfeed_11401 1 0 decap_w0
xfeed_10799 1 0 decap_w0
xfeed_10798 1 0 decap_w0
xfeed_10797 1 0 decap_w0
xfeed_10796 1 0 decap_w0
xfeed_10795 1 0 decap_w0
xfeed_10794 1 0 decap_w0
xfeed_10793 1 0 decap_w0
xfeed_10792 1 0 decap_w0
xfeed_10791 1 0 decap_w0
xfeed_10790 1 0 decap_w0
xfeed_9517 1 0 decap_w0
xfeed_9516 1 0 decap_w0
xfeed_9515 1 0 decap_w0
xfeed_9514 1 0 decap_w0
xfeed_9513 1 0 decap_w0
xfeed_9512 1 0 decap_w0
xfeed_9511 1 0 decap_w0
xfeed_9510 1 0 decap_w0
xfeed_5209 1 0 decap_w0
xfeed_5208 1 0 decap_w0
xfeed_5207 1 0 decap_w0
xfeed_5206 1 0 decap_w0
xfeed_5205 1 0 decap_w0
xfeed_5204 1 0 decap_w0
xfeed_5203 1 0 decap_w0
xfeed_5202 1 0 decap_w0
xfeed_5201 1 0 decap_w0
xfeed_5200 1 0 decap_w0
xsubckt_77_nexor2_x0 1 0 157 160 156 nexor2_x0
xfeed_27099 1 0 decap_w0
xfeed_27098 1 0 decap_w0
xfeed_27097 1 0 decap_w0
xfeed_27096 1 0 decap_w0
xfeed_27095 1 0 decap_w0
xfeed_27094 1 0 decap_w0
xfeed_27093 1 0 decap_w0
xfeed_27092 1 0 decap_w0
xfeed_27091 1 0 decap_w0
xfeed_27090 1 0 decap_w0
xfeed_26569 1 0 decap_w0
xfeed_26568 1 0 decap_w0
xfeed_26567 1 0 decap_w0
xfeed_26566 1 0 decap_w0
xfeed_26565 1 0 decap_w0
xfeed_26564 1 0 decap_w0
xfeed_26563 1 0 decap_w0
xfeed_26562 1 0 decap_w0
xfeed_26561 1 0 decap_w0
xfeed_26560 1 0 decap_w0
xfeed_22259 1 0 decap_w0
xfeed_22258 1 0 decap_w0
xfeed_22257 1 0 decap_w0
xfeed_22256 1 0 decap_w0
xfeed_22255 1 0 decap_w0
xfeed_22254 1 0 decap_w0
xfeed_22253 1 0 decap_w0
xfeed_22252 1 0 decap_w0
xfeed_22251 1 0 decap_w0
xfeed_22250 1 0 decap_w0
xfeed_21729 1 0 decap_w0
xfeed_21728 1 0 decap_w0
xfeed_21727 1 0 decap_w0
xfeed_21726 1 0 decap_w0
xfeed_21725 1 0 decap_w0
xfeed_21724 1 0 decap_w0
xfeed_21723 1 0 decap_w0
xfeed_21722 1 0 decap_w0
xfeed_21721 1 0 decap_w0
xfeed_21720 1 0 decap_w0
xfeed_9519 1 0 decap_w0
xfeed_9518 1 0 decap_w0
xfeed_4599 1 0 decap_w0
xfeed_4598 1 0 decap_w0
xfeed_4597 1 0 decap_w0
xfeed_4596 1 0 decap_w0
xfeed_4595 1 0 decap_w0
xfeed_4594 1 0 decap_w0
xfeed_4593 1 0 decap_w0
xfeed_4592 1 0 decap_w0
xfeed_4591 1 0 decap_w0
xfeed_4590 1 0 decap_w0
xspare_feed_99 1 0 decap_w0
xspare_feed_98 1 0 tie
xspare_feed_97 1 0 tie
xspare_feed_96 1 0 decap_w0
xspare_feed_95 1 0 tie
xspare_feed_94 1 0 tie
xspare_feed_93 1 0 decap_w0
xspare_feed_92 1 0 tie
xspare_feed_91 1 0 tie
xspare_feed_90 1 0 decap_w0
xsubckt_68_nexor2_x0 1 0 163 166 162 nexor2_x0
xfeed_16259 1 0 decap_w0
xfeed_16258 1 0 decap_w0
xfeed_16257 1 0 decap_w0
xfeed_16256 1 0 decap_w0
xfeed_16255 1 0 decap_w0
xfeed_16254 1 0 decap_w0
xfeed_16253 1 0 decap_w0
xfeed_16252 1 0 decap_w0
xfeed_16251 1 0 decap_w0
xfeed_16250 1 0 decap_w0
xfeed_15729 1 0 decap_w0
xfeed_15728 1 0 decap_w0
xfeed_15727 1 0 decap_w0
xfeed_15726 1 0 decap_w0
xfeed_15725 1 0 decap_w0
xfeed_15724 1 0 decap_w0
xfeed_15723 1 0 decap_w0
xfeed_15722 1 0 decap_w0
xfeed_15721 1 0 decap_w0
xfeed_15720 1 0 decap_w0
xfeed_11419 1 0 decap_w0
xfeed_11418 1 0 decap_w0
xfeed_11417 1 0 decap_w0
xfeed_11416 1 0 decap_w0
xfeed_11415 1 0 decap_w0
xfeed_11414 1 0 decap_w0
xfeed_11413 1 0 decap_w0
xfeed_11412 1 0 decap_w0
xfeed_11411 1 0 decap_w0
xfeed_11410 1 0 decap_w0
xfeed_9524 1 0 decap_w0
xfeed_9523 1 0 decap_w0
xfeed_9522 1 0 decap_w0
xfeed_9521 1 0 decap_w0
xfeed_9520 1 0 decap_w0
xfeed_5219 1 0 decap_w0
xfeed_5218 1 0 decap_w0
xfeed_5217 1 0 decap_w0
xfeed_5216 1 0 decap_w0
xfeed_5215 1 0 decap_w0
xfeed_5214 1 0 decap_w0
xfeed_5213 1 0 decap_w0
xfeed_5212 1 0 decap_w0
xfeed_5211 1 0 decap_w0
xfeed_5210 1 0 decap_w0
xsubckt_59_nexor2_x0 1 0 171 172 169 nexor2_x0
xfeed_26579 1 0 decap_w0
xfeed_26578 1 0 decap_w0
xfeed_26577 1 0 decap_w0
xfeed_26576 1 0 decap_w0
xfeed_26575 1 0 decap_w0
xfeed_26574 1 0 decap_w0
xfeed_26573 1 0 decap_w0
xfeed_26572 1 0 decap_w0
xfeed_26571 1 0 decap_w0
xfeed_26570 1 0 decap_w0
xfeed_22269 1 0 decap_w0
xfeed_22268 1 0 decap_w0
xfeed_22267 1 0 decap_w0
xfeed_22266 1 0 decap_w0
xfeed_22265 1 0 decap_w0
xfeed_22264 1 0 decap_w0
xfeed_22263 1 0 decap_w0
xfeed_22262 1 0 decap_w0
xfeed_22261 1 0 decap_w0
xfeed_22260 1 0 decap_w0
xfeed_21739 1 0 decap_w0
xfeed_21738 1 0 decap_w0
xfeed_21737 1 0 decap_w0
xfeed_21736 1 0 decap_w0
xfeed_21735 1 0 decap_w0
xfeed_21734 1 0 decap_w0
xfeed_21733 1 0 decap_w0
xfeed_21732 1 0 decap_w0
xfeed_21731 1 0 decap_w0
xfeed_21730 1 0 decap_w0
xfeed_9529 1 0 decap_w0
xfeed_9528 1 0 decap_w0
xfeed_9527 1 0 decap_w0
xfeed_9526 1 0 decap_w0
xfeed_9525 1 0 decap_w0
xfeed_16269 1 0 decap_w0
xfeed_16268 1 0 decap_w0
xfeed_16267 1 0 decap_w0
xfeed_16266 1 0 decap_w0
xfeed_16265 1 0 decap_w0
xfeed_16264 1 0 decap_w0
xfeed_16263 1 0 decap_w0
xfeed_16262 1 0 decap_w0
xfeed_16261 1 0 decap_w0
xfeed_16260 1 0 decap_w0
xfeed_15739 1 0 decap_w0
xfeed_15738 1 0 decap_w0
xfeed_15737 1 0 decap_w0
xfeed_15736 1 0 decap_w0
xfeed_15735 1 0 decap_w0
xfeed_15734 1 0 decap_w0
xfeed_15733 1 0 decap_w0
xfeed_15732 1 0 decap_w0
xfeed_15731 1 0 decap_w0
xfeed_15730 1 0 decap_w0
xfeed_11429 1 0 decap_w0
xfeed_11428 1 0 decap_w0
xfeed_11427 1 0 decap_w0
xfeed_11426 1 0 decap_w0
xfeed_11425 1 0 decap_w0
xfeed_11424 1 0 decap_w0
xfeed_11423 1 0 decap_w0
xfeed_11422 1 0 decap_w0
xfeed_11421 1 0 decap_w0
xfeed_11420 1 0 decap_w0
xfeed_9531 1 0 decap_w0
xfeed_9530 1 0 decap_w0
xfeed_5229 1 0 decap_w0
xfeed_5228 1 0 decap_w0
xfeed_5227 1 0 decap_w0
xfeed_5226 1 0 decap_w0
xfeed_5225 1 0 decap_w0
xfeed_5224 1 0 decap_w0
xfeed_5223 1 0 decap_w0
xfeed_5222 1 0 decap_w0
xfeed_5221 1 0 decap_w0
xfeed_5220 1 0 decap_w0
xfeed_26587 1 0 decap_w0
xfeed_26586 1 0 decap_w0
xfeed_26585 1 0 decap_w0
xfeed_26584 1 0 decap_w0
xfeed_26583 1 0 decap_w0
xfeed_26582 1 0 decap_w0
xfeed_26581 1 0 decap_w0
xfeed_26580 1 0 decap_w0
xfeed_22279 1 0 decap_w0
xfeed_22278 1 0 decap_w0
xfeed_22277 1 0 decap_w0
xfeed_22276 1 0 decap_w0
xfeed_22275 1 0 decap_w0
xfeed_22274 1 0 decap_w0
xfeed_22273 1 0 decap_w0
xfeed_22272 1 0 decap_w0
xfeed_22271 1 0 decap_w0
xfeed_22270 1 0 decap_w0
xfeed_21748 1 0 decap_w0
xfeed_21747 1 0 decap_w0
xfeed_21746 1 0 decap_w0
xfeed_21745 1 0 decap_w0
xfeed_21744 1 0 decap_w0
xfeed_21743 1 0 decap_w0
xfeed_21742 1 0 decap_w0
xfeed_21741 1 0 decap_w0
xfeed_21740 1 0 decap_w0
xfeed_9539 1 0 decap_w0
xfeed_9538 1 0 decap_w0
xfeed_9537 1 0 decap_w0
xfeed_9536 1 0 decap_w0
xfeed_9535 1 0 decap_w0
xfeed_9534 1 0 decap_w0
xfeed_9533 1 0 decap_w0
xfeed_9532 1 0 decap_w0
xfeed_26589 1 0 decap_w0
xfeed_26588 1 0 decap_w0
xfeed_21749 1 0 decap_w0
xfeed_16279 1 0 decap_w0
xfeed_16278 1 0 decap_w0
xfeed_16277 1 0 decap_w0
xfeed_16276 1 0 decap_w0
xfeed_16275 1 0 decap_w0
xfeed_16274 1 0 decap_w0
xfeed_16273 1 0 decap_w0
xfeed_16272 1 0 decap_w0
xfeed_16271 1 0 decap_w0
xfeed_16270 1 0 decap_w0
xfeed_15749 1 0 decap_w0
xfeed_15748 1 0 decap_w0
xfeed_15747 1 0 decap_w0
xfeed_15746 1 0 decap_w0
xfeed_15745 1 0 decap_w0
xfeed_15744 1 0 decap_w0
xfeed_15743 1 0 decap_w0
xfeed_15742 1 0 decap_w0
xfeed_15741 1 0 decap_w0
xfeed_15740 1 0 decap_w0
xfeed_11439 1 0 decap_w0
xfeed_11438 1 0 decap_w0
xfeed_11437 1 0 decap_w0
xfeed_11436 1 0 decap_w0
xfeed_11435 1 0 decap_w0
xfeed_11434 1 0 decap_w0
xfeed_11433 1 0 decap_w0
xfeed_11432 1 0 decap_w0
xfeed_11431 1 0 decap_w0
xfeed_11430 1 0 decap_w0
xfeed_10909 1 0 decap_w0
xfeed_10908 1 0 decap_w0
xfeed_10907 1 0 decap_w0
xfeed_10906 1 0 decap_w0
xfeed_10905 1 0 decap_w0
xfeed_10904 1 0 decap_w0
xfeed_10903 1 0 decap_w0
xfeed_10902 1 0 decap_w0
xfeed_10901 1 0 decap_w0
xfeed_10900 1 0 decap_w0
xfeed_5238 1 0 decap_w0
xfeed_5237 1 0 decap_w0
xfeed_5236 1 0 decap_w0
xfeed_5235 1 0 decap_w0
xfeed_5234 1 0 decap_w0
xfeed_5233 1 0 decap_w0
xfeed_5232 1 0 decap_w0
xfeed_5231 1 0 decap_w0
xfeed_5230 1 0 decap_w0
xfeed_27209 1 0 decap_w0
xfeed_27208 1 0 decap_w0
xfeed_27207 1 0 decap_w0
xfeed_27206 1 0 decap_w0
xfeed_27205 1 0 decap_w0
xfeed_27204 1 0 decap_w0
xfeed_27203 1 0 decap_w0
xfeed_27202 1 0 decap_w0
xfeed_27201 1 0 decap_w0
xfeed_27200 1 0 decap_w0
xfeed_26594 1 0 decap_w0
xfeed_26593 1 0 decap_w0
xfeed_26592 1 0 decap_w0
xfeed_26591 1 0 decap_w0
xfeed_26590 1 0 decap_w0
xfeed_22289 1 0 decap_w0
xfeed_22288 1 0 decap_w0
xfeed_22287 1 0 decap_w0
xfeed_22286 1 0 decap_w0
xfeed_22285 1 0 decap_w0
xfeed_22284 1 0 decap_w0
xfeed_22283 1 0 decap_w0
xfeed_22282 1 0 decap_w0
xfeed_22281 1 0 decap_w0
xfeed_22280 1 0 decap_w0
xfeed_21755 1 0 decap_w0
xfeed_21754 1 0 decap_w0
xfeed_21753 1 0 decap_w0
xfeed_21752 1 0 decap_w0
xfeed_21751 1 0 decap_w0
xfeed_21750 1 0 decap_w0
xfeed_9549 1 0 decap_w0
xfeed_9548 1 0 decap_w0
xfeed_9547 1 0 decap_w0
xfeed_9546 1 0 decap_w0
xfeed_9545 1 0 decap_w0
xfeed_9544 1 0 decap_w0
xfeed_9543 1 0 decap_w0
xfeed_9542 1 0 decap_w0
xfeed_9541 1 0 decap_w0
xfeed_9540 1 0 decap_w0
xfeed_5239 1 0 decap_w0
xfeed_4709 1 0 decap_w0
xfeed_4708 1 0 decap_w0
xfeed_4707 1 0 decap_w0
xfeed_4706 1 0 decap_w0
xfeed_4705 1 0 decap_w0
xfeed_4704 1 0 decap_w0
xfeed_4703 1 0 decap_w0
xfeed_4702 1 0 decap_w0
xfeed_4701 1 0 decap_w0
xfeed_4700 1 0 decap_w0
xfeed_26599 1 0 decap_w0
xfeed_26598 1 0 decap_w0
xfeed_26597 1 0 decap_w0
xfeed_26596 1 0 decap_w0
xfeed_26595 1 0 decap_w0
xfeed_21759 1 0 decap_w0
xfeed_21758 1 0 decap_w0
xfeed_21757 1 0 decap_w0
xfeed_21756 1 0 decap_w0
xfeed_16289 1 0 decap_w0
xfeed_16288 1 0 decap_w0
xfeed_16287 1 0 decap_w0
xfeed_16286 1 0 decap_w0
xfeed_16285 1 0 decap_w0
xfeed_16284 1 0 decap_w0
xfeed_16283 1 0 decap_w0
xfeed_16282 1 0 decap_w0
xfeed_16281 1 0 decap_w0
xfeed_16280 1 0 decap_w0
xfeed_15759 1 0 decap_w0
xfeed_15758 1 0 decap_w0
xfeed_15757 1 0 decap_w0
xfeed_15756 1 0 decap_w0
xfeed_15755 1 0 decap_w0
xfeed_15754 1 0 decap_w0
xfeed_15753 1 0 decap_w0
xfeed_15752 1 0 decap_w0
xfeed_15751 1 0 decap_w0
xfeed_15750 1 0 decap_w0
xfeed_11449 1 0 decap_w0
xfeed_11448 1 0 decap_w0
xfeed_11447 1 0 decap_w0
xfeed_11446 1 0 decap_w0
xfeed_11445 1 0 decap_w0
xfeed_11444 1 0 decap_w0
xfeed_11443 1 0 decap_w0
xfeed_11442 1 0 decap_w0
xfeed_11441 1 0 decap_w0
xfeed_11440 1 0 decap_w0
xfeed_10919 1 0 decap_w0
xfeed_10918 1 0 decap_w0
xfeed_10917 1 0 decap_w0
xfeed_10916 1 0 decap_w0
xfeed_10915 1 0 decap_w0
xfeed_10914 1 0 decap_w0
xfeed_10913 1 0 decap_w0
xfeed_10912 1 0 decap_w0
xfeed_10911 1 0 decap_w0
xfeed_10910 1 0 decap_w0
xfeed_5245 1 0 decap_w0
xfeed_5244 1 0 decap_w0
xfeed_5243 1 0 decap_w0
xfeed_5242 1 0 decap_w0
xfeed_5241 1 0 decap_w0
xfeed_5240 1 0 decap_w0
xfeed_27219 1 0 decap_w0
xfeed_27218 1 0 decap_w0
xfeed_27217 1 0 decap_w0
xfeed_27216 1 0 decap_w0
xfeed_27215 1 0 decap_w0
xfeed_27214 1 0 decap_w0
xfeed_27213 1 0 decap_w0
xfeed_27212 1 0 decap_w0
xfeed_27211 1 0 decap_w0
xfeed_27210 1 0 decap_w0
xfeed_22299 1 0 decap_w0
xfeed_22298 1 0 decap_w0
xfeed_22297 1 0 decap_w0
xfeed_22296 1 0 decap_w0
xfeed_22295 1 0 decap_w0
xfeed_22294 1 0 decap_w0
xfeed_22293 1 0 decap_w0
xfeed_22292 1 0 decap_w0
xfeed_22291 1 0 decap_w0
xfeed_22290 1 0 decap_w0
xfeed_21762 1 0 decap_w0
xfeed_21761 1 0 decap_w0
xfeed_21760 1 0 decap_w0
xfeed_9559 1 0 decap_w0
xfeed_9558 1 0 decap_w0
xfeed_9557 1 0 decap_w0
xfeed_9556 1 0 decap_w0
xfeed_9555 1 0 decap_w0
xfeed_9554 1 0 decap_w0
xfeed_9553 1 0 decap_w0
xfeed_9552 1 0 decap_w0
xfeed_9551 1 0 decap_w0
xfeed_9550 1 0 decap_w0
xfeed_5249 1 0 decap_w0
xfeed_5248 1 0 decap_w0
xfeed_5247 1 0 decap_w0
xfeed_5246 1 0 decap_w0
xfeed_4719 1 0 decap_w0
xfeed_4718 1 0 decap_w0
xfeed_4717 1 0 decap_w0
xfeed_4716 1 0 decap_w0
xfeed_4715 1 0 decap_w0
xfeed_4714 1 0 decap_w0
xfeed_4713 1 0 decap_w0
xfeed_4712 1 0 decap_w0
xfeed_4711 1 0 decap_w0
xfeed_4710 1 0 decap_w0
xfeed_21769 1 0 decap_w0
xfeed_21768 1 0 decap_w0
xfeed_21767 1 0 decap_w0
xfeed_21766 1 0 decap_w0
xfeed_21765 1 0 decap_w0
xfeed_21764 1 0 decap_w0
xfeed_21763 1 0 decap_w0
xfeed_16299 1 0 decap_w0
xfeed_16298 1 0 decap_w0
xfeed_16297 1 0 decap_w0
xfeed_16296 1 0 decap_w0
xfeed_16295 1 0 decap_w0
xfeed_16294 1 0 decap_w0
xfeed_16293 1 0 decap_w0
xfeed_16292 1 0 decap_w0
xfeed_16291 1 0 decap_w0
xfeed_16290 1 0 decap_w0
xfeed_15769 1 0 decap_w0
xfeed_15768 1 0 decap_w0
xfeed_15767 1 0 decap_w0
xfeed_15766 1 0 decap_w0
xfeed_15765 1 0 decap_w0
xfeed_15764 1 0 decap_w0
xfeed_15763 1 0 decap_w0
xfeed_15762 1 0 decap_w0
xfeed_15761 1 0 decap_w0
xfeed_15760 1 0 decap_w0
xfeed_11459 1 0 decap_w0
xfeed_11458 1 0 decap_w0
xfeed_11457 1 0 decap_w0
xfeed_11456 1 0 decap_w0
xfeed_11455 1 0 decap_w0
xfeed_11454 1 0 decap_w0
xfeed_11453 1 0 decap_w0
xfeed_11452 1 0 decap_w0
xfeed_11451 1 0 decap_w0
xfeed_11450 1 0 decap_w0
xfeed_10929 1 0 decap_w0
xfeed_10928 1 0 decap_w0
xfeed_10927 1 0 decap_w0
xfeed_10926 1 0 tie
xfeed_10925 1 0 decap_w0
xfeed_10924 1 0 decap_w0
xfeed_10923 1 0 decap_w0
xfeed_10922 1 0 decap_w0
xfeed_10921 1 0 decap_w0
xfeed_10920 1 0 decap_w0
xfeed_5252 1 0 decap_w0
xfeed_5251 1 0 decap_w0
xfeed_5250 1 0 decap_w0
xfeed_27229 1 0 decap_w0
xfeed_27228 1 0 decap_w0
xfeed_27227 1 0 decap_w0
xfeed_27226 1 0 decap_w0
xfeed_27225 1 0 decap_w0
xfeed_27224 1 0 decap_w0
xfeed_27223 1 0 decap_w0
xfeed_27222 1 0 decap_w0
xfeed_27221 1 0 decap_w0
xfeed_27220 1 0 decap_w0
xfeed_9569 1 0 decap_w0
xfeed_9568 1 0 decap_w0
xfeed_9567 1 0 decap_w0
xfeed_9566 1 0 decap_w0
xfeed_9565 1 0 decap_w0
xfeed_9564 1 0 decap_w0
xfeed_9563 1 0 decap_w0
xfeed_9562 1 0 decap_w0
xfeed_9561 1 0 decap_w0
xfeed_9560 1 0 decap_w0
xfeed_5259 1 0 decap_w0
xfeed_5258 1 0 decap_w0
xfeed_5257 1 0 decap_w0
xfeed_5256 1 0 decap_w0
xfeed_5255 1 0 decap_w0
xfeed_5254 1 0 decap_w0
xfeed_5253 1 0 decap_w0
xfeed_4729 1 0 decap_w0
xfeed_4728 1 0 decap_w0
xfeed_4727 1 0 decap_w0
xfeed_4726 1 0 decap_w0
xfeed_4725 1 0 decap_w0
xfeed_4724 1 0 decap_w0
xfeed_4723 1 0 decap_w0
xfeed_4722 1 0 decap_w0
xfeed_4721 1 0 decap_w0
xfeed_4720 1 0 decap_w0
xfeed_21779 1 0 decap_w0
xfeed_21778 1 0 decap_w0
xfeed_21777 1 0 tie
xfeed_21776 1 0 decap_w0
xfeed_21775 1 0 decap_w0
xfeed_21774 1 0 decap_w0
xfeed_21773 1 0 decap_w0
xfeed_21772 1 0 decap_w0
xfeed_21771 1 0 decap_w0
xfeed_21770 1 0 decap_w0
xfeed_15779 1 0 decap_w0
xfeed_15778 1 0 decap_w0
xfeed_15777 1 0 decap_w0
xfeed_15776 1 0 decap_w0
xfeed_15775 1 0 decap_w0
xfeed_15774 1 0 decap_w0
xfeed_15773 1 0 decap_w0
xfeed_15772 1 0 decap_w0
xfeed_15771 1 0 decap_w0
xfeed_15770 1 0 decap_w0
xfeed_11469 1 0 decap_w0
xfeed_11468 1 0 decap_w0
xfeed_11467 1 0 decap_w0
xfeed_11466 1 0 decap_w0
xfeed_11465 1 0 decap_w0
xfeed_11464 1 0 decap_w0
xfeed_11463 1 0 decap_w0
xfeed_11462 1 0 decap_w0
xfeed_11461 1 0 decap_w0
xfeed_11460 1 0 decap_w0
xfeed_10939 1 0 decap_w0
xfeed_10938 1 0 decap_w0
xfeed_10937 1 0 decap_w0
xfeed_10936 1 0 decap_w0
xfeed_10935 1 0 decap_w0
xfeed_10934 1 0 decap_w0
xfeed_10933 1 0 decap_w0
xfeed_10932 1 0 decap_w0
xfeed_10931 1 0 decap_w0
xfeed_10930 1 0 decap_w0
xfeed_27239 1 0 decap_w0
xfeed_27238 1 0 decap_w0
xfeed_27237 1 0 decap_w0
xfeed_27236 1 0 decap_w0
xfeed_27235 1 0 decap_w0
xfeed_27234 1 0 decap_w0
xfeed_27233 1 0 decap_w0
xfeed_27232 1 0 decap_w0
xfeed_27231 1 0 decap_w0
xfeed_27230 1 0 decap_w0
xfeed_26709 1 0 decap_w0
xfeed_26708 1 0 decap_w0
xfeed_26707 1 0 decap_w0
xfeed_26706 1 0 decap_w0
xfeed_26705 1 0 decap_w0
xfeed_26704 1 0 decap_w0
xfeed_26703 1 0 decap_w0
xfeed_26702 1 0 decap_w0
xfeed_26701 1 0 decap_w0
xfeed_26700 1 0 decap_w0
xfeed_9579 1 0 decap_w0
xfeed_9578 1 0 decap_w0
xfeed_9577 1 0 decap_w0
xfeed_9576 1 0 decap_w0
xfeed_9575 1 0 decap_w0
xfeed_9574 1 0 decap_w0
xfeed_9573 1 0 decap_w0
xfeed_9572 1 0 decap_w0
xfeed_9571 1 0 decap_w0
xfeed_9570 1 0 decap_w0
xfeed_5269 1 0 decap_w0
xfeed_5268 1 0 decap_w0
xfeed_5267 1 0 decap_w0
xfeed_5266 1 0 decap_w0
xfeed_5265 1 0 decap_w0
xfeed_5264 1 0 decap_w0
xfeed_5263 1 0 decap_w0
xfeed_5262 1 0 decap_w0
xfeed_5261 1 0 decap_w0
xfeed_5260 1 0 decap_w0
xfeed_4739 1 0 decap_w0
xfeed_4738 1 0 decap_w0
xfeed_4737 1 0 decap_w0
xfeed_4736 1 0 decap_w0
xfeed_4735 1 0 decap_w0
xfeed_4734 1 0 decap_w0
xfeed_4733 1 0 decap_w0
xfeed_4732 1 0 decap_w0
xfeed_4731 1 0 decap_w0
xfeed_4730 1 0 decap_w0
xfeed_21789 1 0 decap_w0
xfeed_21788 1 0 decap_w0
xfeed_21787 1 0 decap_w0
xfeed_21786 1 0 decap_w0
xfeed_21785 1 0 decap_w0
xfeed_21784 1 0 decap_w0
xfeed_21783 1 0 decap_w0
xfeed_21782 1 0 decap_w0
xfeed_21781 1 0 decap_w0
xfeed_21780 1 0 decap_w0
xfeed_15789 1 0 decap_w0
xfeed_15788 1 0 decap_w0
xfeed_15787 1 0 decap_w0
xfeed_15786 1 0 decap_w0
xfeed_15785 1 0 decap_w0
xfeed_15784 1 0 decap_w0
xfeed_15783 1 0 decap_w0
xfeed_15782 1 0 decap_w0
xfeed_15781 1 0 decap_w0
xfeed_15780 1 0 decap_w0
xfeed_11479 1 0 decap_w0
xfeed_11478 1 0 decap_w0
xfeed_11477 1 0 decap_w0
xfeed_11476 1 0 decap_w0
xfeed_11475 1 0 decap_w0
xfeed_11474 1 0 decap_w0
xfeed_11473 1 0 decap_w0
xfeed_11472 1 0 decap_w0
xfeed_11471 1 0 decap_w0
xfeed_11470 1 0 decap_w0
xfeed_10949 1 0 decap_w0
xfeed_10948 1 0 decap_w0
xfeed_10947 1 0 decap_w0
xfeed_10946 1 0 decap_w0
xfeed_10945 1 0 decap_w0
xfeed_10944 1 0 decap_w0
xfeed_10943 1 0 decap_w0
xfeed_10942 1 0 decap_w0
xfeed_10941 1 0 decap_w0
xfeed_10940 1 0 decap_w0
xfeed_27249 1 0 decap_w0
xfeed_27248 1 0 decap_w0
xfeed_27247 1 0 decap_w0
xfeed_27246 1 0 decap_w0
xfeed_27245 1 0 decap_w0
xfeed_27244 1 0 decap_w0
xfeed_27243 1 0 decap_w0
xfeed_27242 1 0 decap_w0
xfeed_27241 1 0 decap_w0
xfeed_27240 1 0 decap_w0
xfeed_26719 1 0 decap_w0
xfeed_26718 1 0 decap_w0
xfeed_26717 1 0 decap_w0
xfeed_26716 1 0 decap_w0
xfeed_26715 1 0 decap_w0
xfeed_26714 1 0 decap_w0
xfeed_26713 1 0 decap_w0
xfeed_26712 1 0 decap_w0
xfeed_26711 1 0 decap_w0
xfeed_26710 1 0 decap_w0
xfeed_22409 1 0 decap_w0
xfeed_22408 1 0 decap_w0
xfeed_22407 1 0 decap_w0
xfeed_22406 1 0 decap_w0
xfeed_22405 1 0 decap_w0
xfeed_22404 1 0 decap_w0
xfeed_22403 1 0 decap_w0
xfeed_22402 1 0 decap_w0
xfeed_22401 1 0 decap_w0
xfeed_22400 1 0 decap_w0
xfeed_9589 1 0 decap_w0
xfeed_9588 1 0 decap_w0
xfeed_9587 1 0 decap_w0
xfeed_9586 1 0 decap_w0
xfeed_9585 1 0 decap_w0
xfeed_9584 1 0 decap_w0
xfeed_9583 1 0 decap_w0
xfeed_9582 1 0 decap_w0
xfeed_9581 1 0 decap_w0
xfeed_9580 1 0 decap_w0
xfeed_5279 1 0 decap_w0
xfeed_5278 1 0 decap_w0
xfeed_5277 1 0 decap_w0
xfeed_5276 1 0 decap_w0
xfeed_5275 1 0 decap_w0
xfeed_5274 1 0 decap_w0
xfeed_5273 1 0 decap_w0
xfeed_5272 1 0 decap_w0
xfeed_5271 1 0 decap_w0
xfeed_5270 1 0 decap_w0
xfeed_4749 1 0 decap_w0
xfeed_4748 1 0 decap_w0
xfeed_4747 1 0 decap_w0
xfeed_4746 1 0 decap_w0
xfeed_4745 1 0 decap_w0
xfeed_4744 1 0 decap_w0
xfeed_4743 1 0 decap_w0
xfeed_4742 1 0 decap_w0
xfeed_4741 1 0 decap_w0
xfeed_4740 1 0 decap_w0
xfeed_21799 1 0 decap_w0
xfeed_21798 1 0 decap_w0
xfeed_21797 1 0 decap_w0
xfeed_21796 1 0 decap_w0
xfeed_21795 1 0 decap_w0
xfeed_21794 1 0 decap_w0
xfeed_21793 1 0 decap_w0
xfeed_21792 1 0 decap_w0
xfeed_21791 1 0 decap_w0
xfeed_21790 1 0 decap_w0
xfeed_16409 1 0 decap_w0
xfeed_16408 1 0 decap_w0
xfeed_16407 1 0 decap_w0
xfeed_16406 1 0 decap_w0
xfeed_16405 1 0 decap_w0
xfeed_16404 1 0 decap_w0
xfeed_16403 1 0 decap_w0
xfeed_16402 1 0 decap_w0
xfeed_16401 1 0 decap_w0
xfeed_16400 1 0 decap_w0
xfeed_15799 1 0 decap_w0
xfeed_15798 1 0 decap_w0
xfeed_15797 1 0 decap_w0
xfeed_15796 1 0 decap_w0
xfeed_15795 1 0 decap_w0
xfeed_15794 1 0 decap_w0
xfeed_15793 1 0 decap_w0
xfeed_15792 1 0 decap_w0
xfeed_15791 1 0 decap_w0
xfeed_15790 1 0 decap_w0
xfeed_11489 1 0 decap_w0
xfeed_11488 1 0 decap_w0
xfeed_11487 1 0 decap_w0
xfeed_11486 1 0 decap_w0
xfeed_11485 1 0 decap_w0
xfeed_11484 1 0 decap_w0
xfeed_11483 1 0 decap_w0
xfeed_11482 1 0 decap_w0
xfeed_11481 1 0 decap_w0
xfeed_11480 1 0 decap_w0
xfeed_10959 1 0 decap_w0
xfeed_10958 1 0 decap_w0
xfeed_10957 1 0 tie
xfeed_10956 1 0 decap_w0
xfeed_10955 1 0 decap_w0
xfeed_10954 1 0 decap_w0
xfeed_10953 1 0 decap_w0
xfeed_10952 1 0 decap_w0
xfeed_10951 1 0 decap_w0
xfeed_10950 1 0 decap_w0
xfeed_27259 1 0 decap_w0
xfeed_27258 1 0 decap_w0
xfeed_27257 1 0 decap_w0
xfeed_27256 1 0 decap_w0
xfeed_27255 1 0 decap_w0
xfeed_27254 1 0 decap_w0
xfeed_27253 1 0 decap_w0
xfeed_27252 1 0 decap_w0
xfeed_27251 1 0 decap_w0
xfeed_27250 1 0 decap_w0
xfeed_26727 1 0 decap_w0
xfeed_26726 1 0 decap_w0
xfeed_26725 1 0 decap_w0
xfeed_26724 1 0 decap_w0
xfeed_26723 1 0 decap_w0
xfeed_26722 1 0 decap_w0
xfeed_26721 1 0 decap_w0
xfeed_26720 1 0 decap_w0
xfeed_22419 1 0 decap_w0
xfeed_22418 1 0 decap_w0
xfeed_22417 1 0 decap_w0
xfeed_22416 1 0 decap_w0
xfeed_22415 1 0 decap_w0
xfeed_22414 1 0 decap_w0
xfeed_22413 1 0 decap_w0
xfeed_22412 1 0 decap_w0
xfeed_22411 1 0 decap_w0
xfeed_22410 1 0 decap_w0
xfeed_12100 1 0 decap_w0
xfeed_9599 1 0 decap_w0
xfeed_9598 1 0 decap_w0
xfeed_9597 1 0 decap_w0
xfeed_9596 1 0 decap_w0
xfeed_9595 1 0 decap_w0
xfeed_9594 1 0 decap_w0
xfeed_9593 1 0 decap_w0
xfeed_9592 1 0 decap_w0
xfeed_9591 1 0 decap_w0
xfeed_9590 1 0 decap_w0
xfeed_5289 1 0 decap_w0
xfeed_5288 1 0 decap_w0
xfeed_5287 1 0 decap_w0
xfeed_5286 1 0 decap_w0
xfeed_5285 1 0 decap_w0
xfeed_5284 1 0 decap_w0
xfeed_5283 1 0 decap_w0
xfeed_5282 1 0 decap_w0
xfeed_5281 1 0 decap_w0
xfeed_5280 1 0 decap_w0
xfeed_4759 1 0 decap_w0
xfeed_4758 1 0 decap_w0
xfeed_4757 1 0 decap_w0
xfeed_4756 1 0 decap_w0
xfeed_4755 1 0 decap_w0
xfeed_4754 1 0 decap_w0
xfeed_4753 1 0 decap_w0
xfeed_4752 1 0 decap_w0
xfeed_4751 1 0 decap_w0
xfeed_4750 1 0 decap_w0
xfeed_26729 1 0 decap_w0
xfeed_26728 1 0 decap_w0
xfeed_16419 1 0 decap_w0
xfeed_16418 1 0 decap_w0
xfeed_16417 1 0 decap_w0
xfeed_16416 1 0 decap_w0
xfeed_16415 1 0 decap_w0
xfeed_16414 1 0 decap_w0
xfeed_16413 1 0 decap_w0
xfeed_16412 1 0 decap_w0
xfeed_16411 1 0 decap_w0
xfeed_16410 1 0 decap_w0
xfeed_12109 1 0 decap_w0
xfeed_12108 1 0 decap_w0
xfeed_12107 1 0 decap_w0
xfeed_12106 1 0 decap_w0
xfeed_12105 1 0 decap_w0
xfeed_12104 1 0 decap_w0
xfeed_12103 1 0 decap_w0
xfeed_12102 1 0 decap_w0
xfeed_12101 1 0 decap_w0
xfeed_11499 1 0 decap_w0
xfeed_11498 1 0 decap_w0
xfeed_11497 1 0 decap_w0
xfeed_11496 1 0 decap_w0
xfeed_11495 1 0 decap_w0
xfeed_11494 1 0 decap_w0
xfeed_11493 1 0 decap_w0
xfeed_11492 1 0 decap_w0
xfeed_11491 1 0 decap_w0
xfeed_11490 1 0 decap_w0
xfeed_10969 1 0 decap_w0
xfeed_10968 1 0 decap_w0
xfeed_10967 1 0 decap_w0
xfeed_10966 1 0 decap_w0
xfeed_10965 1 0 decap_w0
xfeed_10964 1 0 decap_w0
xfeed_10963 1 0 decap_w0
xfeed_10962 1 0 decap_w0
xfeed_10961 1 0 decap_w0
xfeed_10960 1 0 decap_w0
xfeed_27269 1 0 decap_w0
xfeed_27268 1 0 decap_w0
xfeed_27267 1 0 decap_w0
xfeed_27266 1 0 decap_w0
xfeed_27265 1 0 decap_w0
xfeed_27264 1 0 decap_w0
xfeed_27263 1 0 decap_w0
xfeed_27262 1 0 decap_w0
xfeed_27261 1 0 decap_w0
xfeed_27260 1 0 decap_w0
xfeed_26734 1 0 decap_w0
xfeed_26733 1 0 decap_w0
xfeed_26732 1 0 decap_w0
xfeed_26731 1 0 decap_w0
xfeed_26730 1 0 decap_w0
xfeed_22429 1 0 decap_w0
xfeed_22428 1 0 decap_w0
xfeed_22427 1 0 decap_w0
xfeed_22426 1 0 decap_w0
xfeed_22425 1 0 decap_w0
xfeed_22424 1 0 decap_w0
xfeed_22423 1 0 decap_w0
xfeed_22422 1 0 decap_w0
xfeed_22421 1 0 decap_w0
xfeed_22420 1 0 decap_w0
xfeed_5299 1 0 decap_w0
xfeed_5298 1 0 decap_w0
xfeed_5297 1 0 decap_w0
xfeed_5296 1 0 decap_w0
xfeed_5295 1 0 decap_w0
xfeed_5294 1 0 decap_w0
xfeed_5293 1 0 decap_w0
xfeed_5292 1 0 decap_w0
xfeed_5291 1 0 decap_w0
xfeed_5290 1 0 decap_w0
xfeed_4769 1 0 decap_w0
xfeed_4768 1 0 decap_w0
xfeed_4767 1 0 decap_w0
xfeed_4766 1 0 decap_w0
xfeed_4765 1 0 decap_w0
xfeed_4764 1 0 decap_w0
xfeed_4763 1 0 decap_w0
xfeed_4762 1 0 decap_w0
xfeed_4761 1 0 decap_w0
xfeed_4760 1 0 decap_w0
xfeed_26739 1 0 decap_w0
xfeed_26738 1 0 decap_w0
xfeed_26737 1 0 decap_w0
xfeed_26736 1 0 decap_w0
xfeed_26735 1 0 decap_w0
xfeed_16429 1 0 decap_w0
xfeed_16428 1 0 decap_w0
xfeed_16427 1 0 decap_w0
xfeed_16426 1 0 decap_w0
xfeed_16425 1 0 decap_w0
xfeed_16424 1 0 decap_w0
xfeed_16423 1 0 decap_w0
xfeed_16422 1 0 decap_w0
xfeed_16421 1 0 decap_w0
xfeed_16420 1 0 decap_w0
xfeed_12119 1 0 decap_w0
xfeed_12118 1 0 decap_w0
xfeed_12117 1 0 decap_w0
xfeed_12116 1 0 decap_w0
xfeed_12115 1 0 decap_w0
xfeed_12114 1 0 decap_w0
xfeed_12113 1 0 decap_w0
xfeed_12112 1 0 decap_w0
xfeed_12111 1 0 decap_w0
xfeed_12110 1 0 decap_w0
xfeed_10979 1 0 decap_w0
xfeed_10978 1 0 decap_w0
xfeed_10977 1 0 decap_w0
xfeed_10976 1 0 decap_w0
xfeed_10975 1 0 decap_w0
xfeed_10974 1 0 decap_w0
xfeed_10973 1 0 decap_w0
xfeed_10972 1 0 decap_w0
xfeed_10971 1 0 decap_w0
xfeed_10970 1 0 decap_w0
xfeed_27279 1 0 decap_w0
xfeed_27278 1 0 decap_w0
xfeed_27277 1 0 decap_w0
xfeed_27276 1 0 decap_w0
xfeed_27275 1 0 decap_w0
xfeed_27274 1 0 decap_w0
xfeed_27273 1 0 decap_w0
xfeed_27272 1 0 decap_w0
xfeed_27271 1 0 decap_w0
xfeed_27270 1 0 decap_w0
xfeed_26741 1 0 decap_w0
xfeed_26740 1 0 decap_w0
xfeed_22439 1 0 decap_w0
xfeed_22438 1 0 decap_w0
xfeed_22437 1 0 decap_w0
xfeed_22436 1 0 decap_w0
xfeed_22435 1 0 decap_w0
xfeed_22434 1 0 decap_w0
xfeed_22433 1 0 decap_w0
xfeed_22432 1 0 decap_w0
xfeed_22431 1 0 decap_w0
xfeed_22430 1 0 decap_w0
xfeed_21902 1 0 decap_w0
xfeed_21901 1 0 decap_w0
xfeed_21900 1 0 decap_w0
xfeed_4779 1 0 decap_w0
xfeed_4778 1 0 decap_w0
xfeed_4777 1 0 decap_w0
xfeed_4776 1 0 decap_w0
xfeed_4775 1 0 decap_w0
xfeed_4774 1 0 decap_w0
xfeed_4773 1 0 decap_w0
xfeed_4772 1 0 decap_w0
xfeed_4771 1 0 decap_w0
xfeed_4770 1 0 decap_w0
xfeed_26749 1 0 decap_w0
xfeed_26748 1 0 decap_w0
xfeed_26747 1 0 decap_w0
xfeed_26746 1 0 decap_w0
xfeed_26745 1 0 decap_w0
xfeed_26744 1 0 decap_w0
xfeed_26743 1 0 decap_w0
xfeed_26742 1 0 decap_w0
xfeed_21909 1 0 decap_w0
xfeed_21908 1 0 decap_w0
xfeed_21907 1 0 decap_w0
xfeed_21906 1 0 decap_w0
xfeed_21905 1 0 decap_w0
xfeed_21904 1 0 decap_w0
xfeed_21903 1 0 decap_w0
xfeed_16439 1 0 decap_w0
xfeed_16438 1 0 decap_w0
xfeed_16437 1 0 decap_w0
xfeed_16436 1 0 decap_w0
xfeed_16435 1 0 decap_w0
xfeed_16434 1 0 decap_w0
xfeed_16433 1 0 decap_w0
xfeed_16432 1 0 decap_w0
xfeed_16431 1 0 decap_w0
xfeed_16430 1 0 decap_w0
xfeed_15909 1 0 decap_w0
xfeed_15908 1 0 decap_w0
xfeed_15907 1 0 decap_w0
xfeed_15906 1 0 decap_w0
xfeed_15905 1 0 decap_w0
xfeed_15904 1 0 decap_w0
xfeed_15903 1 0 decap_w0
xfeed_15902 1 0 decap_w0
xfeed_15901 1 0 decap_w0
xfeed_15900 1 0 decap_w0
xfeed_12129 1 0 decap_w0
xfeed_12128 1 0 decap_w0
xfeed_12127 1 0 decap_w0
xfeed_12126 1 0 decap_w0
xfeed_12125 1 0 decap_w0
xfeed_12124 1 0 decap_w0
xfeed_12123 1 0 decap_w0
xfeed_12122 1 0 decap_w0
xfeed_12121 1 0 decap_w0
xfeed_12120 1 0 decap_w0
xfeed_10989 1 0 decap_w0
xfeed_10988 1 0 decap_w0
xfeed_10987 1 0 decap_w0
xfeed_10986 1 0 decap_w0
xfeed_10985 1 0 decap_w0
xfeed_10984 1 0 decap_w0
xfeed_10983 1 0 decap_w0
xfeed_10982 1 0 decap_w0
xfeed_10981 1 0 decap_w0
xfeed_10980 1 0 decap_w0
xfeed_27287 1 0 decap_w0
xfeed_27286 1 0 decap_w0
xfeed_27285 1 0 decap_w0
xfeed_27284 1 0 decap_w0
xfeed_27283 1 0 decap_w0
xfeed_27282 1 0 decap_w0
xfeed_27281 1 0 decap_w0
xfeed_27280 1 0 decap_w0
xfeed_22448 1 0 decap_w0
xfeed_22447 1 0 decap_w0
xfeed_22446 1 0 decap_w0
xfeed_22445 1 0 decap_w0
xfeed_22444 1 0 decap_w0
xfeed_22443 1 0 decap_w0
xfeed_22442 1 0 decap_w0
xfeed_22441 1 0 decap_w0
xfeed_22440 1 0 decap_w0
xfeed_9709 1 0 decap_w0
xfeed_9708 1 0 decap_w0
xfeed_9707 1 0 decap_w0
xfeed_9706 1 0 decap_w0
xfeed_9705 1 0 decap_w0
xfeed_9704 1 0 decap_w0
xfeed_9703 1 0 decap_w0
xfeed_9702 1 0 decap_w0
xfeed_9701 1 0 decap_w0
xfeed_9700 1 0 decap_w0
xfeed_4789 1 0 decap_w0
xfeed_4788 1 0 decap_w0
xfeed_4787 1 0 decap_w0
xfeed_4786 1 0 decap_w0
xfeed_4785 1 0 decap_w0
xfeed_4784 1 0 decap_w0
xfeed_4783 1 0 decap_w0
xfeed_4782 1 0 decap_w0
xfeed_4781 1 0 decap_w0
xfeed_4780 1 0 decap_w0
xfeed_27289 1 0 decap_w0
xfeed_27288 1 0 decap_w0
xfeed_26759 1 0 decap_w0
xfeed_26758 1 0 decap_w0
xfeed_26757 1 0 decap_w0
xfeed_26756 1 0 decap_w0
xfeed_26755 1 0 decap_w0
xfeed_26754 1 0 decap_w0
xfeed_26753 1 0 decap_w0
xfeed_26752 1 0 decap_w0
xfeed_26751 1 0 decap_w0
xfeed_26750 1 0 decap_w0
xfeed_22449 1 0 decap_w0
xfeed_21919 1 0 decap_w0
xfeed_21918 1 0 decap_w0
xfeed_21917 1 0 decap_w0
xfeed_21916 1 0 decap_w0
xfeed_21915 1 0 decap_w0
xfeed_21914 1 0 decap_w0
xfeed_21913 1 0 decap_w0
xfeed_21912 1 0 decap_w0
xfeed_21911 1 0 decap_w0
xfeed_21910 1 0 decap_w0
xfeed_16449 1 0 decap_w0
xfeed_16448 1 0 decap_w0
xfeed_16447 1 0 decap_w0
xfeed_16446 1 0 decap_w0
xfeed_16445 1 0 decap_w0
xfeed_16444 1 0 decap_w0
xfeed_16443 1 0 decap_w0
xfeed_16442 1 0 decap_w0
xfeed_16441 1 0 decap_w0
xfeed_16440 1 0 decap_w0
xfeed_15919 1 0 decap_w0
xfeed_15918 1 0 decap_w0
xfeed_15917 1 0 decap_w0
xfeed_15916 1 0 decap_w0
xfeed_15915 1 0 decap_w0
xfeed_15914 1 0 decap_w0
xfeed_15913 1 0 decap_w0
xfeed_15912 1 0 decap_w0
xfeed_15911 1 0 decap_w0
xfeed_15910 1 0 decap_w0
xfeed_12139 1 0 decap_w0
xfeed_12138 1 0 decap_w0
xfeed_12137 1 0 decap_w0
xfeed_12136 1 0 decap_w0
xfeed_12135 1 0 decap_w0
xfeed_12134 1 0 tie
xfeed_12133 1 0 decap_w0
xfeed_12132 1 0 decap_w0
xfeed_12131 1 0 decap_w0
xfeed_12130 1 0 decap_w0
xfeed_11609 1 0 decap_w0
xfeed_11608 1 0 decap_w0
xfeed_11607 1 0 decap_w0
xfeed_11606 1 0 decap_w0
xfeed_11605 1 0 decap_w0
xfeed_11604 1 0 decap_w0
xfeed_11603 1 0 decap_w0
xfeed_11602 1 0 decap_w0
xfeed_11601 1 0 decap_w0
xfeed_11600 1 0 decap_w0
xfeed_10999 1 0 decap_w0
xfeed_10998 1 0 decap_w0
xfeed_10997 1 0 decap_w0
xfeed_10996 1 0 decap_w0
xfeed_10995 1 0 decap_w0
xfeed_10994 1 0 decap_w0
xfeed_10993 1 0 decap_w0
xfeed_10992 1 0 decap_w0
xfeed_10991 1 0 decap_w0
xfeed_10990 1 0 decap_w0
xfeed_27294 1 0 decap_w0
xfeed_27293 1 0 decap_w0
xfeed_27292 1 0 decap_w0
xfeed_27291 1 0 decap_w0
xfeed_27290 1 0 decap_w0
xfeed_22455 1 0 decap_w0
xfeed_22454 1 0 decap_w0
xfeed_22453 1 0 decap_w0
xfeed_22452 1 0 decap_w0
xfeed_22451 1 0 decap_w0
xfeed_22450 1 0 decap_w0
xfeed_9719 1 0 decap_w0
xfeed_9718 1 0 decap_w0
xfeed_9717 1 0 decap_w0
xfeed_9715 1 0 tie
xfeed_9714 1 0 decap_w0
xfeed_9713 1 0 decap_w0
xfeed_9712 1 0 decap_w0
xfeed_9711 1 0 decap_w0
xfeed_9710 1 0 decap_w0
xfeed_5409 1 0 decap_w0
xfeed_5408 1 0 decap_w0
xfeed_5407 1 0 decap_w0
xfeed_5406 1 0 decap_w0
xfeed_5405 1 0 decap_w0
xfeed_5404 1 0 decap_w0
xfeed_5403 1 0 decap_w0
xfeed_5402 1 0 decap_w0
xfeed_5401 1 0 decap_w0
xfeed_5400 1 0 decap_w0
xfeed_4799 1 0 decap_w0
xfeed_4798 1 0 decap_w0
xfeed_4797 1 0 decap_w0
xfeed_4796 1 0 decap_w0
xfeed_4795 1 0 decap_w0
xfeed_4794 1 0 decap_w0
xfeed_4793 1 0 decap_w0
xfeed_4792 1 0 decap_w0
xfeed_4791 1 0 decap_w0
xfeed_4790 1 0 decap_w0
xfeed_27299 1 0 decap_w0
xfeed_27298 1 0 decap_w0
xfeed_27297 1 0 decap_w0
xfeed_27296 1 0 decap_w0
xfeed_27295 1 0 decap_w0
xfeed_26769 1 0 decap_w0
xfeed_26768 1 0 decap_w0
xfeed_26767 1 0 decap_w0
xfeed_26766 1 0 decap_w0
xfeed_26765 1 0 decap_w0
xfeed_26764 1 0 decap_w0
xfeed_26763 1 0 decap_w0
xfeed_26762 1 0 decap_w0
xfeed_26761 1 0 decap_w0
xfeed_26760 1 0 decap_w0
xfeed_22459 1 0 decap_w0
xfeed_22458 1 0 decap_w0
xfeed_22457 1 0 decap_w0
xfeed_22456 1 0 decap_w0
xfeed_21929 1 0 decap_w0
xfeed_21928 1 0 decap_w0
xfeed_21927 1 0 decap_w0
xfeed_21926 1 0 decap_w0
xfeed_21925 1 0 decap_w0
xfeed_21924 1 0 decap_w0
xfeed_21923 1 0 decap_w0
xfeed_21922 1 0 decap_w0
xfeed_21921 1 0 decap_w0
xfeed_21920 1 0 decap_w0
xfeed_16459 1 0 decap_w0
xfeed_16458 1 0 decap_w0
xfeed_16457 1 0 decap_w0
xfeed_16456 1 0 decap_w0
xfeed_16455 1 0 decap_w0
xfeed_16454 1 0 decap_w0
xfeed_16453 1 0 decap_w0
xfeed_16452 1 0 decap_w0
xfeed_16451 1 0 decap_w0
xfeed_16450 1 0 decap_w0
xfeed_15929 1 0 decap_w0
xfeed_15928 1 0 decap_w0
xfeed_15927 1 0 decap_w0
xfeed_15926 1 0 decap_w0
xfeed_15925 1 0 decap_w0
xfeed_15924 1 0 decap_w0
xfeed_15923 1 0 decap_w0
xfeed_15922 1 0 decap_w0
xfeed_15921 1 0 decap_w0
xfeed_15920 1 0 decap_w0
xfeed_12149 1 0 decap_w0
xfeed_12148 1 0 decap_w0
xfeed_12147 1 0 decap_w0
xfeed_12146 1 0 decap_w0
xfeed_12145 1 0 decap_w0
xfeed_12144 1 0 decap_w0
xfeed_12143 1 0 decap_w0
xfeed_12142 1 0 decap_w0
xfeed_12141 1 0 decap_w0
xfeed_12140 1 0 decap_w0
xfeed_11619 1 0 decap_w0
xfeed_11618 1 0 decap_w0
xfeed_11617 1 0 decap_w0
xfeed_11616 1 0 decap_w0
xfeed_11615 1 0 decap_w0
xfeed_11614 1 0 decap_w0
xfeed_11613 1 0 decap_w0
xfeed_11612 1 0 decap_w0
xfeed_11611 1 0 decap_w0
xfeed_11610 1 0 decap_w0
xfeed_1100 1 0 decap_w0
xfeed_1101 1 0 decap_w0
xfeed_1102 1 0 decap_w0
xfeed_1103 1 0 decap_w0
xfeed_1104 1 0 decap_w0
xfeed_1105 1 0 decap_w0
xfeed_1106 1 0 decap_w0
xfeed_22462 1 0 decap_w0
xfeed_22461 1 0 decap_w0
xfeed_22460 1 0 decap_w0
xfeed_9729 1 0 decap_w0
xfeed_9728 1 0 decap_w0
xfeed_9727 1 0 decap_w0
xfeed_9726 1 0 decap_w0
xfeed_9725 1 0 decap_w0
xfeed_9724 1 0 decap_w0
xfeed_9723 1 0 decap_w0
xfeed_9722 1 0 decap_w0
xfeed_9721 1 0 decap_w0
xfeed_9720 1 0 decap_w0
xfeed_5419 1 0 decap_w0
xfeed_5418 1 0 decap_w0
xfeed_5417 1 0 decap_w0
xfeed_5416 1 0 decap_w0
xfeed_5415 1 0 decap_w0
xfeed_5414 1 0 decap_w0
xfeed_5413 1 0 decap_w0
xfeed_5412 1 0 decap_w0
xfeed_5411 1 0 decap_w0
xfeed_5410 1 0 decap_w0
xfeed_1107 1 0 decap_w0
xfeed_1108 1 0 decap_w0
xfeed_1109 1 0 decap_w0
xfeed_26779 1 0 decap_w0
xfeed_26778 1 0 decap_w0
xfeed_26777 1 0 decap_w0
xfeed_26776 1 0 decap_w0
xfeed_26775 1 0 decap_w0
xfeed_26774 1 0 decap_w0
xfeed_26773 1 0 decap_w0
xfeed_26772 1 0 decap_w0
xfeed_26771 1 0 decap_w0
xfeed_26770 1 0 decap_w0
xfeed_22469 1 0 decap_w0
xfeed_22468 1 0 decap_w0
xfeed_22467 1 0 decap_w0
xfeed_22466 1 0 decap_w0
xfeed_22465 1 0 decap_w0
xfeed_22464 1 0 decap_w0
xfeed_22463 1 0 decap_w0
xfeed_21939 1 0 decap_w0
xfeed_21938 1 0 decap_w0
xfeed_21937 1 0 decap_w0
xfeed_21936 1 0 decap_w0
xfeed_21935 1 0 decap_w0
xfeed_21934 1 0 decap_w0
xfeed_21933 1 0 decap_w0
xfeed_21932 1 0 decap_w0
xfeed_21931 1 0 decap_w0
xfeed_21930 1 0 decap_w0
xfeed_16469 1 0 decap_w0
xfeed_16468 1 0 decap_w0
xfeed_16467 1 0 decap_w0
xfeed_16466 1 0 decap_w0
xfeed_16465 1 0 decap_w0
xfeed_16464 1 0 decap_w0
xfeed_16463 1 0 decap_w0
xfeed_16462 1 0 decap_w0
xfeed_16461 1 0 decap_w0
xfeed_16460 1 0 decap_w0
xfeed_15939 1 0 decap_w0
xfeed_15938 1 0 decap_w0
xfeed_15937 1 0 decap_w0
xfeed_15936 1 0 decap_w0
xfeed_15935 1 0 decap_w0
xfeed_15934 1 0 decap_w0
xfeed_15933 1 0 decap_w0
xfeed_15932 1 0 decap_w0
xfeed_15931 1 0 decap_w0
xfeed_15930 1 0 decap_w0
xfeed_12159 1 0 decap_w0
xfeed_12158 1 0 decap_w0
xfeed_12157 1 0 decap_w0
xfeed_12156 1 0 decap_w0
xfeed_12155 1 0 decap_w0
xfeed_12154 1 0 decap_w0
xfeed_12153 1 0 decap_w0
xfeed_12152 1 0 decap_w0
xfeed_12151 1 0 decap_w0
xfeed_12150 1 0 decap_w0
xfeed_11629 1 0 decap_w0
xfeed_11628 1 0 decap_w0
xfeed_11627 1 0 decap_w0
xfeed_11626 1 0 decap_w0
xfeed_11625 1 0 decap_w0
xfeed_11624 1 0 decap_w0
xfeed_11623 1 0 decap_w0
xfeed_11622 1 0 decap_w0
xfeed_11621 1 0 decap_w0
xfeed_11620 1 0 decap_w0
xsubckt_8_xor2_x0 1 0 38 60 134 xor2_x0
xfeed_1110 1 0 decap_w0
xfeed_1111 1 0 decap_w0
xfeed_1112 1 0 decap_w0
xfeed_1113 1 0 decap_w0
xfeed_9739 1 0 decap_w0
xfeed_9738 1 0 decap_w0
xfeed_9737 1 0 decap_w0
xfeed_9736 1 0 decap_w0
xfeed_9735 1 0 decap_w0
xfeed_9734 1 0 decap_w0
xfeed_9733 1 0 decap_w0
xfeed_9732 1 0 decap_w0
xfeed_9731 1 0 decap_w0
xfeed_9730 1 0 decap_w0
xfeed_5429 1 0 decap_w0
xfeed_5428 1 0 decap_w0
xfeed_5427 1 0 decap_w0
xfeed_5426 1 0 decap_w0
xfeed_5425 1 0 decap_w0
xfeed_5424 1 0 decap_w0
xfeed_5423 1 0 decap_w0
xfeed_5422 1 0 decap_w0
xfeed_5421 1 0 decap_w0
xfeed_5420 1 0 decap_w0
xfeed_1114 1 0 decap_w0
xfeed_1115 1 0 decap_w0
xfeed_1116 1 0 decap_w0
xfeed_1117 1 0 decap_w0
xfeed_1118 1 0 decap_w0
xfeed_1119 1 0 decap_w0
xfeed_26789 1 0 decap_w0
xfeed_26788 1 0 decap_w0
xfeed_26787 1 0 decap_w0
xfeed_26786 1 0 decap_w0
xfeed_26785 1 0 decap_w0
xfeed_26784 1 0 decap_w0
xfeed_26783 1 0 decap_w0
xfeed_26782 1 0 decap_w0
xfeed_26781 1 0 decap_w0
xfeed_26780 1 0 decap_w0
xfeed_22479 1 0 decap_w0
xfeed_22478 1 0 decap_w0
xfeed_22477 1 0 decap_w0
xfeed_22476 1 0 decap_w0
xfeed_22475 1 0 decap_w0
xfeed_22474 1 0 decap_w0
xfeed_22473 1 0 decap_w0
xfeed_22472 1 0 decap_w0
xfeed_22471 1 0 decap_w0
xfeed_22470 1 0 decap_w0
xfeed_21949 1 0 decap_w0
xfeed_21948 1 0 decap_w0
xfeed_21947 1 0 decap_w0
xfeed_21946 1 0 decap_w0
xfeed_21945 1 0 tie
xfeed_21944 1 0 decap_w0
xfeed_21943 1 0 decap_w0
xfeed_21942 1 0 decap_w0
xfeed_21941 1 0 decap_w0
xfeed_21940 1 0 decap_w0
xfeed_16479 1 0 decap_w0
xfeed_16478 1 0 decap_w0
xfeed_16477 1 0 decap_w0
xfeed_16476 1 0 decap_w0
xfeed_16475 1 0 decap_w0
xfeed_16474 1 0 decap_w0
xfeed_16473 1 0 decap_w0
xfeed_16472 1 0 decap_w0
xfeed_16471 1 0 decap_w0
xfeed_16470 1 0 decap_w0
xfeed_15949 1 0 decap_w0
xfeed_15948 1 0 decap_w0
xfeed_15947 1 0 decap_w0
xfeed_15946 1 0 decap_w0
xfeed_15945 1 0 decap_w0
xfeed_15944 1 0 decap_w0
xfeed_15943 1 0 decap_w0
xfeed_15942 1 0 decap_w0
xfeed_15941 1 0 decap_w0
xfeed_15940 1 0 decap_w0
xfeed_12169 1 0 decap_w0
xfeed_12168 1 0 decap_w0
xfeed_12167 1 0 decap_w0
xfeed_12166 1 0 decap_w0
xfeed_12165 1 0 decap_w0
xfeed_12164 1 0 decap_w0
xfeed_12163 1 0 decap_w0
xfeed_12162 1 0 decap_w0
xfeed_12161 1 0 decap_w0
xfeed_12160 1 0 decap_w0
xfeed_11639 1 0 decap_w0
xfeed_11638 1 0 decap_w0
xfeed_11637 1 0 decap_w0
xfeed_11636 1 0 decap_w0
xfeed_11635 1 0 decap_w0
xfeed_11634 1 0 decap_w0
xfeed_11633 1 0 decap_w0
xfeed_11632 1 0 decap_w0
xfeed_11631 1 0 decap_w0
xfeed_11630 1 0 decap_w0
xfeed_1120 1 0 decap_w0
xfeed_27409 1 0 decap_w0
xfeed_27408 1 0 decap_w0
xfeed_27407 1 0 decap_w0
xfeed_27406 1 0 decap_w0
xfeed_27405 1 0 decap_w0
xfeed_27404 1 0 decap_w0
xfeed_27403 1 0 decap_w0
xfeed_27402 1 0 decap_w0
xfeed_27401 1 0 decap_w0
xfeed_27400 1 0 decap_w0
xfeed_9749 1 0 decap_w0
xfeed_9748 1 0 decap_w0
xfeed_9747 1 0 decap_w0
xfeed_9746 1 0 decap_w0
xfeed_9745 1 0 decap_w0
xfeed_9744 1 0 decap_w0
xfeed_9743 1 0 decap_w0
xfeed_9742 1 0 decap_w0
xfeed_9741 1 0 decap_w0
xfeed_9740 1 0 decap_w0
xfeed_5439 1 0 decap_w0
xfeed_5438 1 0 decap_w0
xfeed_5437 1 0 decap_w0
xfeed_5436 1 0 decap_w0
xfeed_5435 1 0 decap_w0
xfeed_5434 1 0 decap_w0
xfeed_5433 1 0 decap_w0
xfeed_5432 1 0 decap_w0
xfeed_5431 1 0 decap_w0
xfeed_5430 1 0 decap_w0
xfeed_4909 1 0 decap_w0
xfeed_4908 1 0 decap_w0
xfeed_4907 1 0 decap_w0
xfeed_4906 1 0 decap_w0
xfeed_4905 1 0 decap_w0
xfeed_4904 1 0 decap_w0
xfeed_4903 1 0 decap_w0
xfeed_4902 1 0 decap_w0
xfeed_4901 1 0 decap_w0
xfeed_4900 1 0 decap_w0
xfeed_1121 1 0 decap_w0
xfeed_1122 1 0 decap_w0
xfeed_1123 1 0 decap_w0
xfeed_1124 1 0 decap_w0
xfeed_1125 1 0 decap_w0
xfeed_1126 1 0 decap_w0
xfeed_1127 1 0 decap_w0
xfeed_1128 1 0 decap_w0
xfeed_1129 1 0 decap_w0
xfeed_26799 1 0 decap_w0
xfeed_26798 1 0 decap_w0
xfeed_26797 1 0 decap_w0
xfeed_26796 1 0 decap_w0
xfeed_26795 1 0 decap_w0
xfeed_26794 1 0 decap_w0
xfeed_26793 1 0 decap_w0
xfeed_26792 1 0 decap_w0
xfeed_26791 1 0 decap_w0
xfeed_26790 1 0 decap_w0
xfeed_22489 1 0 decap_w0
xfeed_22488 1 0 decap_w0
xfeed_22487 1 0 decap_w0
xfeed_22486 1 0 decap_w0
xfeed_22485 1 0 decap_w0
xfeed_22484 1 0 decap_w0
xfeed_22483 1 0 decap_w0
xfeed_22482 1 0 decap_w0
xfeed_22481 1 0 decap_w0
xfeed_22480 1 0 decap_w0
xfeed_21959 1 0 decap_w0
xfeed_21958 1 0 decap_w0
xfeed_21957 1 0 decap_w0
xfeed_21956 1 0 decap_w0
xfeed_21955 1 0 decap_w0
xfeed_21954 1 0 decap_w0
xfeed_21953 1 0 decap_w0
xfeed_21952 1 0 decap_w0
xfeed_21951 1 0 decap_w0
xfeed_21950 1 0 decap_w0
xfeed_16489 1 0 decap_w0
xfeed_16488 1 0 decap_w0
xfeed_16487 1 0 decap_w0
xfeed_16486 1 0 decap_w0
xfeed_16485 1 0 decap_w0
xfeed_16484 1 0 decap_w0
xfeed_16483 1 0 decap_w0
xfeed_16482 1 0 decap_w0
xfeed_16481 1 0 decap_w0
xfeed_16480 1 0 decap_w0
xfeed_15959 1 0 decap_w0
xfeed_15958 1 0 decap_w0
xfeed_15957 1 0 decap_w0
xfeed_15956 1 0 decap_w0
xfeed_15955 1 0 decap_w0
xfeed_15954 1 0 decap_w0
xfeed_15953 1 0 decap_w0
xfeed_15952 1 0 decap_w0
xfeed_15951 1 0 decap_w0
xfeed_15950 1 0 decap_w0
xfeed_12179 1 0 decap_w0
xfeed_12178 1 0 decap_w0
xfeed_12177 1 0 decap_w0
xfeed_12176 1 0 decap_w0
xfeed_12175 1 0 decap_w0
xfeed_12174 1 0 decap_w0
xfeed_12173 1 0 tie
xfeed_12172 1 0 decap_w0
xfeed_12171 1 0 decap_w0
xfeed_12170 1 0 decap_w0
xfeed_11649 1 0 decap_w0
xfeed_11648 1 0 decap_w0
xfeed_11647 1 0 decap_w0
xfeed_11646 1 0 decap_w0
xfeed_11645 1 0 decap_w0
xfeed_11644 1 0 decap_w0
xfeed_11643 1 0 decap_w0
xfeed_11642 1 0 decap_w0
xfeed_11641 1 0 decap_w0
xfeed_11640 1 0 decap_w0
xfeed_27419 1 0 decap_w0
xfeed_27418 1 0 decap_w0
xfeed_27417 1 0 decap_w0
xfeed_27416 1 0 decap_w0
xfeed_27415 1 0 decap_w0
xfeed_27414 1 0 decap_w0
xfeed_27413 1 0 decap_w0
xfeed_27412 1 0 decap_w0
xfeed_27411 1 0 decap_w0
xfeed_27410 1 0 decap_w0
xfeed_23109 1 0 decap_w0
xfeed_23108 1 0 decap_w0
xfeed_23107 1 0 decap_w0
xfeed_23106 1 0 decap_w0
xfeed_23105 1 0 decap_w0
xfeed_23104 1 0 decap_w0
xfeed_23103 1 0 decap_w0
xfeed_23102 1 0 decap_w0
xfeed_23101 1 0 decap_w0
xfeed_23100 1 0 decap_w0
xfeed_9759 1 0 decap_w0
xfeed_9758 1 0 decap_w0
xfeed_9757 1 0 decap_w0
xfeed_9756 1 0 decap_w0
xfeed_9755 1 0 decap_w0
xfeed_9753 1 0 decap_w0
xfeed_9752 1 0 decap_w0
xfeed_9751 1 0 decap_w0
xfeed_9750 1 0 decap_w0
xfeed_5449 1 0 decap_w0
xfeed_5448 1 0 decap_w0
xfeed_5447 1 0 decap_w0
xfeed_5446 1 0 decap_w0
xfeed_5445 1 0 decap_w0
xfeed_5444 1 0 decap_w0
xfeed_5443 1 0 decap_w0
xfeed_5442 1 0 decap_w0
xfeed_5441 1 0 decap_w0
xfeed_5440 1 0 decap_w0
xfeed_4919 1 0 decap_w0
xfeed_4918 1 0 decap_w0
xfeed_4917 1 0 decap_w0
xfeed_4916 1 0 decap_w0
xfeed_4915 1 0 decap_w0
xfeed_4914 1 0 decap_w0
xfeed_4913 1 0 decap_w0
xfeed_4912 1 0 decap_w0
xfeed_4911 1 0 decap_w0
xfeed_4910 1 0 decap_w0
xfeed_1130 1 0 decap_w0
xfeed_1131 1 0 decap_w0
xfeed_1132 1 0 decap_w0
xfeed_1133 1 0 decap_w0
xfeed_1134 1 0 decap_w0
xfeed_1135 1 0 decap_w0
xfeed_1136 1 0 decap_w0
xfeed_1137 1 0 decap_w0
xfeed_1138 1 0 decap_w0
xfeed_1139 1 0 decap_w0
xfeed_22499 1 0 decap_w0
xfeed_22498 1 0 decap_w0
xfeed_22497 1 0 decap_w0
xfeed_22496 1 0 decap_w0
xfeed_22495 1 0 decap_w0
xfeed_22494 1 0 decap_w0
xfeed_22493 1 0 decap_w0
xfeed_22492 1 0 decap_w0
xfeed_22491 1 0 decap_w0
xfeed_22490 1 0 decap_w0
xfeed_21969 1 0 decap_w0
xfeed_21968 1 0 decap_w0
xfeed_21967 1 0 decap_w0
xfeed_21966 1 0 decap_w0
xfeed_21965 1 0 decap_w0
xfeed_21964 1 0 decap_w0
xfeed_21963 1 0 decap_w0
xfeed_21962 1 0 decap_w0
xfeed_21961 1 0 decap_w0
xfeed_21960 1 0 decap_w0
xfeed_17109 1 0 decap_w0
xfeed_17108 1 0 decap_w0
xfeed_17107 1 0 decap_w0
xfeed_17106 1 0 decap_w0
xfeed_17105 1 0 decap_w0
xfeed_17104 1 0 decap_w0
xfeed_17103 1 0 decap_w0
xfeed_17102 1 0 decap_w0
xfeed_17101 1 0 decap_w0
xfeed_17100 1 0 decap_w0
xfeed_16499 1 0 decap_w0
xfeed_16498 1 0 decap_w0
xfeed_16497 1 0 decap_w0
xfeed_16496 1 0 decap_w0
xfeed_16495 1 0 decap_w0
xfeed_16494 1 0 decap_w0
xfeed_16493 1 0 decap_w0
xfeed_16492 1 0 decap_w0
xfeed_16491 1 0 decap_w0
xfeed_16490 1 0 decap_w0
xfeed_15969 1 0 decap_w0
xfeed_15968 1 0 decap_w0
xfeed_15967 1 0 decap_w0
xfeed_15966 1 0 decap_w0
xfeed_15965 1 0 decap_w0
xfeed_15964 1 0 decap_w0
xfeed_15963 1 0 decap_w0
xfeed_15962 1 0 decap_w0
xfeed_15961 1 0 decap_w0
xfeed_15960 1 0 decap_w0
xfeed_12189 1 0 decap_w0
xfeed_12188 1 0 decap_w0
xfeed_12187 1 0 decap_w0
xfeed_12186 1 0 decap_w0
xfeed_12185 1 0 decap_w0
xfeed_12184 1 0 decap_w0
xfeed_12183 1 0 decap_w0
xfeed_12182 1 0 decap_w0
xfeed_12181 1 0 decap_w0
xfeed_12180 1 0 decap_w0
xfeed_11659 1 0 decap_w0
xfeed_11658 1 0 decap_w0
xfeed_11657 1 0 decap_w0
xfeed_11656 1 0 decap_w0
xfeed_11655 1 0 decap_w0
xfeed_11654 1 0 decap_w0
xfeed_11653 1 0 decap_w0
xfeed_11652 1 0 decap_w0
xfeed_11651 1 0 decap_w0
xfeed_11650 1 0 decap_w0
xfeed_27427 1 0 decap_w0
xfeed_27426 1 0 decap_w0
xfeed_27425 1 0 decap_w0
xfeed_27424 1 0 decap_w0
xfeed_27423 1 0 decap_w0
xfeed_27422 1 0 decap_w0
xfeed_27421 1 0 decap_w0
xfeed_27420 1 0 decap_w0
xfeed_23119 1 0 decap_w0
xfeed_23118 1 0 decap_w0
xfeed_23117 1 0 decap_w0
xfeed_23116 1 0 decap_w0
xfeed_23115 1 0 decap_w0
xfeed_23114 1 0 decap_w0
xfeed_23113 1 0 decap_w0
xfeed_23112 1 0 decap_w0
xfeed_23111 1 0 decap_w0
xfeed_23110 1 0 decap_w0
xfeed_9769 1 0 decap_w0
xfeed_9768 1 0 decap_w0
xfeed_9767 1 0 decap_w0
xfeed_9766 1 0 decap_w0
xfeed_9765 1 0 decap_w0
xfeed_9764 1 0 decap_w0
xfeed_9763 1 0 decap_w0
xfeed_9762 1 0 decap_w0
xfeed_9761 1 0 decap_w0
xfeed_9760 1 0 decap_w0
xfeed_5459 1 0 decap_w0
xfeed_5458 1 0 decap_w0
xfeed_5457 1 0 decap_w0
xfeed_5456 1 0 decap_w0
xfeed_5455 1 0 decap_w0
xfeed_5454 1 0 decap_w0
xfeed_5453 1 0 decap_w0
xfeed_5452 1 0 decap_w0
xfeed_5451 1 0 decap_w0
xfeed_5450 1 0 decap_w0
xfeed_4929 1 0 decap_w0
xfeed_4928 1 0 decap_w0
xfeed_4927 1 0 decap_w0
xfeed_4926 1 0 decap_w0
xfeed_4925 1 0 decap_w0
xfeed_4924 1 0 decap_w0
xfeed_4923 1 0 decap_w0
xfeed_4922 1 0 decap_w0
xfeed_4921 1 0 decap_w0
xfeed_4920 1 0 decap_w0
xfeed_1140 1 0 decap_w0
xfeed_1141 1 0 decap_w0
xfeed_1142 1 0 decap_w0
xfeed_1143 1 0 decap_w0
xfeed_1144 1 0 decap_w0
xfeed_1145 1 0 decap_w0
xfeed_1146 1 0 decap_w0
xfeed_1147 1 0 decap_w0
xfeed_1148 1 0 decap_w0
xfeed_1149 1 0 decap_w0
xfeed_27429 1 0 decap_w0
xfeed_27428 1 0 decap_w0
xfeed_21979 1 0 decap_w0
xfeed_21978 1 0 decap_w0
xfeed_21977 1 0 decap_w0
xfeed_21976 1 0 decap_w0
xfeed_21975 1 0 decap_w0
xfeed_21974 1 0 decap_w0
xfeed_21973 1 0 decap_w0
xfeed_21972 1 0 decap_w0
xfeed_21971 1 0 decap_w0
xfeed_21970 1 0 decap_w0
xfeed_17119 1 0 decap_w0
xfeed_17118 1 0 decap_w0
xfeed_17117 1 0 decap_w0
xfeed_17116 1 0 decap_w0
xfeed_17115 1 0 decap_w0
xfeed_17114 1 0 decap_w0
xfeed_17113 1 0 decap_w0
xfeed_17112 1 0 decap_w0
xfeed_17111 1 0 decap_w0
xfeed_17110 1 0 decap_w0
xfeed_15979 1 0 decap_w0
xfeed_15978 1 0 decap_w0
xfeed_15977 1 0 decap_w0
xfeed_15976 1 0 decap_w0
xfeed_15975 1 0 decap_w0
xfeed_15974 1 0 decap_w0
xfeed_15973 1 0 decap_w0
xfeed_15972 1 0 decap_w0
xfeed_15971 1 0 decap_w0
xfeed_15970 1 0 decap_w0
xfeed_12199 1 0 decap_w0
xfeed_12198 1 0 decap_w0
xfeed_12197 1 0 decap_w0
xfeed_12196 1 0 decap_w0
xfeed_12195 1 0 decap_w0
xfeed_12194 1 0 decap_w0
xfeed_12193 1 0 decap_w0
xfeed_12192 1 0 decap_w0
xfeed_12191 1 0 decap_w0
xfeed_12190 1 0 decap_w0
xfeed_11669 1 0 decap_w0
xfeed_11668 1 0 decap_w0
xfeed_11667 1 0 decap_w0
xfeed_11666 1 0 decap_w0
xfeed_11665 1 0 decap_w0
xfeed_11664 1 0 decap_w0
xfeed_11663 1 0 decap_w0
xfeed_11662 1 0 decap_w0
xfeed_11661 1 0 decap_w0
xfeed_11660 1 0 decap_w0
xfeed_27434 1 0 decap_w0
xfeed_27433 1 0 decap_w0
xfeed_27432 1 0 decap_w0
xfeed_27431 1 0 decap_w0
xfeed_27430 1 0 decap_w0
xfeed_23129 1 0 decap_w0
xfeed_23128 1 0 decap_w0
xfeed_23127 1 0 decap_w0
xfeed_23126 1 0 decap_w0
xfeed_23125 1 0 decap_w0
xfeed_23124 1 0 decap_w0
xfeed_23123 1 0 decap_w0
xfeed_23122 1 0 decap_w0
xfeed_23121 1 0 decap_w0
xfeed_23120 1 0 decap_w0
xfeed_9779 1 0 decap_w0
xfeed_9778 1 0 decap_w0
xfeed_9777 1 0 decap_w0
xfeed_9776 1 0 decap_w0
xfeed_9775 1 0 decap_w0
xfeed_9774 1 0 decap_w0
xfeed_9773 1 0 decap_w0
xfeed_9772 1 0 decap_w0
xfeed_9771 1 0 decap_w0
xfeed_9770 1 0 decap_w0
xfeed_5469 1 0 decap_w0
xfeed_5468 1 0 decap_w0
xfeed_5467 1 0 decap_w0
xfeed_5466 1 0 decap_w0
xfeed_5465 1 0 decap_w0
xfeed_5464 1 0 decap_w0
xfeed_5463 1 0 decap_w0
xfeed_5462 1 0 decap_w0
xfeed_5461 1 0 decap_w0
xfeed_5460 1 0 decap_w0
xfeed_4939 1 0 decap_w0
xfeed_4938 1 0 decap_w0
xfeed_4937 1 0 decap_w0
xfeed_4936 1 0 decap_w0
xfeed_4935 1 0 decap_w0
xfeed_4934 1 0 decap_w0
xfeed_4933 1 0 decap_w0
xfeed_4932 1 0 decap_w0
xfeed_4931 1 0 decap_w0
xfeed_4930 1 0 decap_w0
xfeed_1150 1 0 decap_w0
xfeed_1151 1 0 decap_w0
xfeed_1152 1 0 decap_w0
xfeed_1153 1 0 decap_w0
xfeed_1154 1 0 decap_w0
xfeed_1155 1 0 decap_w0
xfeed_1156 1 0 decap_w0
xfeed_1157 1 0 decap_w0
xfeed_1158 1 0 decap_w0
xfeed_1159 1 0 decap_w0
xfeed_27439 1 0 decap_w0
xfeed_27438 1 0 decap_w0
xfeed_27437 1 0 decap_w0
xfeed_27436 1 0 decap_w0
xfeed_27435 1 0 decap_w0
xfeed_26909 1 0 decap_w0
xfeed_26908 1 0 decap_w0
xfeed_26907 1 0 decap_w0
xfeed_26906 1 0 decap_w0
xfeed_26905 1 0 decap_w0
xfeed_26904 1 0 decap_w0
xfeed_26903 1 0 decap_w0
xfeed_26902 1 0 decap_w0
xfeed_26901 1 0 decap_w0
xfeed_26900 1 0 decap_w0
xfeed_21989 1 0 decap_w0
xfeed_21988 1 0 decap_w0
xfeed_21987 1 0 decap_w0
xfeed_21986 1 0 decap_w0
xfeed_21985 1 0 decap_w0
xfeed_21984 1 0 tie
xfeed_21983 1 0 decap_w0
xfeed_21982 1 0 decap_w0
xfeed_21981 1 0 decap_w0
xfeed_21980 1 0 decap_w0
xfeed_17129 1 0 decap_w0
xfeed_17128 1 0 decap_w0
xfeed_17127 1 0 decap_w0
xfeed_17126 1 0 decap_w0
xfeed_17125 1 0 decap_w0
xfeed_17124 1 0 decap_w0
xfeed_17123 1 0 decap_w0
xfeed_17122 1 0 decap_w0
xfeed_17121 1 0 decap_w0
xfeed_17120 1 0 decap_w0
xfeed_15989 1 0 decap_w0
xfeed_15988 1 0 decap_w0
xfeed_15987 1 0 decap_w0
xfeed_15986 1 0 decap_w0
xfeed_15985 1 0 decap_w0
xfeed_15984 1 0 decap_w0
xfeed_15983 1 0 decap_w0
xfeed_15982 1 0 decap_w0
xfeed_15981 1 0 decap_w0
xfeed_15980 1 0 decap_w0
xfeed_11679 1 0 decap_w0
xfeed_11678 1 0 decap_w0
xfeed_11677 1 0 decap_w0
xfeed_11676 1 0 decap_w0
xfeed_11675 1 0 decap_w0
xfeed_11674 1 0 decap_w0
xfeed_11673 1 0 decap_w0
xfeed_11672 1 0 decap_w0
xfeed_11671 1 0 decap_w0
xfeed_11670 1 0 decap_w0
xfeed_27441 1 0 decap_w0
xfeed_27440 1 0 decap_w0
xfeed_23139 1 0 decap_w0
xfeed_23138 1 0 decap_w0
xfeed_23137 1 0 decap_w0
xfeed_23136 1 0 decap_w0
xfeed_23135 1 0 decap_w0
xfeed_23134 1 0 decap_w0
xfeed_23133 1 0 decap_w0
xfeed_23132 1 0 decap_w0
xfeed_23131 1 0 decap_w0
xfeed_23130 1 0 decap_w0
xfeed_22602 1 0 decap_w0
xfeed_22601 1 0 decap_w0
xfeed_22600 1 0 decap_w0
xfeed_9789 1 0 decap_w0
xfeed_9788 1 0 decap_w0
xfeed_9787 1 0 decap_w0
xfeed_9786 1 0 decap_w0
xfeed_9785 1 0 decap_w0
xfeed_9784 1 0 decap_w0
xfeed_9783 1 0 decap_w0
xfeed_9782 1 0 decap_w0
xfeed_9781 1 0 decap_w0
xfeed_9780 1 0 decap_w0
xfeed_5479 1 0 decap_w0
xfeed_5478 1 0 decap_w0
xfeed_5477 1 0 decap_w0
xfeed_5476 1 0 decap_w0
xfeed_5475 1 0 decap_w0
xfeed_5474 1 0 decap_w0
xfeed_5473 1 0 decap_w0
xfeed_5472 1 0 decap_w0
xfeed_5471 1 0 decap_w0
xfeed_5470 1 0 decap_w0
xfeed_4949 1 0 decap_w0
xfeed_4948 1 0 decap_w0
xfeed_4947 1 0 decap_w0
xfeed_4946 1 0 decap_w0
xfeed_4945 1 0 decap_w0
xfeed_4944 1 0 decap_w0
xfeed_4943 1 0 decap_w0
xfeed_4942 1 0 decap_w0
xfeed_4941 1 0 decap_w0
xfeed_4940 1 0 decap_w0
xfeed_1160 1 0 decap_w0
xfeed_1161 1 0 decap_w0
xfeed_1162 1 0 decap_w0
xfeed_1163 1 0 decap_w0
xfeed_1164 1 0 decap_w0
xfeed_1165 1 0 decap_w0
xfeed_1166 1 0 decap_w0
xfeed_1167 1 0 decap_w0
xfeed_1168 1 0 decap_w0
xfeed_1169 1 0 decap_w0
xfeed_27449 1 0 decap_w0
xfeed_27448 1 0 decap_w0
xfeed_27447 1 0 decap_w0
xfeed_27446 1 0 decap_w0
xfeed_27445 1 0 decap_w0
xfeed_27444 1 0 decap_w0
xfeed_27443 1 0 decap_w0
xfeed_27442 1 0 decap_w0
xfeed_26919 1 0 decap_w0
xfeed_26918 1 0 decap_w0
xfeed_26917 1 0 decap_w0
xfeed_26916 1 0 decap_w0
xfeed_26915 1 0 decap_w0
xfeed_26914 1 0 decap_w0
xfeed_26913 1 0 decap_w0
xfeed_26912 1 0 decap_w0
xfeed_26911 1 0 decap_w0
xfeed_26910 1 0 decap_w0
xfeed_22609 1 0 decap_w0
xfeed_22608 1 0 decap_w0
xfeed_22607 1 0 decap_w0
xfeed_22606 1 0 decap_w0
xfeed_22605 1 0 decap_w0
xfeed_22604 1 0 decap_w0
xfeed_22603 1 0 decap_w0
xfeed_21999 1 0 decap_w0
xfeed_21998 1 0 decap_w0
xfeed_21997 1 0 decap_w0
xfeed_21996 1 0 decap_w0
xfeed_21995 1 0 decap_w0
xfeed_21994 1 0 decap_w0
xfeed_21993 1 0 decap_w0
xfeed_21992 1 0 decap_w0
xfeed_21991 1 0 decap_w0
xfeed_21990 1 0 decap_w0
xfeed_17139 1 0 decap_w0
xfeed_17138 1 0 decap_w0
xfeed_17137 1 0 decap_w0
xfeed_17136 1 0 decap_w0
xfeed_17135 1 0 decap_w0
xfeed_17134 1 0 decap_w0
xfeed_17133 1 0 decap_w0
xfeed_17132 1 0 decap_w0
xfeed_17131 1 0 decap_w0
xfeed_17130 1 0 decap_w0
xfeed_16609 1 0 decap_w0
xfeed_16608 1 0 decap_w0
xfeed_16607 1 0 decap_w0
xfeed_16606 1 0 decap_w0
xfeed_16605 1 0 decap_w0
xfeed_16604 1 0 decap_w0
xfeed_16603 1 0 decap_w0
xfeed_16602 1 0 decap_w0
xfeed_16601 1 0 decap_w0
xfeed_16600 1 0 decap_w0
xfeed_15999 1 0 decap_w0
xfeed_15998 1 0 decap_w0
xfeed_15997 1 0 decap_w0
xfeed_15996 1 0 decap_w0
xfeed_15995 1 0 decap_w0
xfeed_15994 1 0 decap_w0
xfeed_15993 1 0 decap_w0
xfeed_15992 1 0 decap_w0
xfeed_15991 1 0 decap_w0
xfeed_15990 1 0 decap_w0
xfeed_11689 1 0 decap_w0
xfeed_11688 1 0 decap_w0
xfeed_11687 1 0 decap_w0
xfeed_11686 1 0 decap_w0
xfeed_11685 1 0 decap_w0
xfeed_11684 1 0 decap_w0
xfeed_11683 1 0 decap_w0
xfeed_11682 1 0 decap_w0
xfeed_11681 1 0 decap_w0
xfeed_11680 1 0 decap_w0
xfeed_23148 1 0 decap_w0
xfeed_23147 1 0 decap_w0
xfeed_23146 1 0 decap_w0
xfeed_23145 1 0 decap_w0
xfeed_23144 1 0 decap_w0
xfeed_23143 1 0 decap_w0
xfeed_23142 1 0 decap_w0
xfeed_23141 1 0 decap_w0
xfeed_23140 1 0 decap_w0
xfeed_9799 1 0 decap_w0
xfeed_9798 1 0 decap_w0
xfeed_9797 1 0 decap_w0
xfeed_9796 1 0 decap_w0
xfeed_9795 1 0 decap_w0
xfeed_9794 1 0 decap_w0
xfeed_9793 1 0 decap_w0
xfeed_9792 1 0 decap_w0
xfeed_9791 1 0 decap_w0
xfeed_9790 1 0 decap_w0
xfeed_5489 1 0 decap_w0
xfeed_5488 1 0 decap_w0
xfeed_5487 1 0 decap_w0
xfeed_5486 1 0 decap_w0
xfeed_5485 1 0 decap_w0
xfeed_5484 1 0 decap_w0
xfeed_5483 1 0 decap_w0
xfeed_5482 1 0 decap_w0
xfeed_5481 1 0 decap_w0
xfeed_5480 1 0 decap_w0
xfeed_4959 1 0 decap_w0
xfeed_4958 1 0 decap_w0
xfeed_4957 1 0 decap_w0
xfeed_4956 1 0 decap_w0
xfeed_4955 1 0 decap_w0
xfeed_4954 1 0 decap_w0
xfeed_4953 1 0 decap_w0
xfeed_4952 1 0 decap_w0
xfeed_4951 1 0 decap_w0
xfeed_4950 1 0 decap_w0
xfeed_1170 1 0 decap_w0
xfeed_1171 1 0 decap_w0
xfeed_1172 1 0 decap_w0
xfeed_1173 1 0 decap_w0
xfeed_1174 1 0 decap_w0
xfeed_1175 1 0 decap_w0
xfeed_1176 1 0 decap_w0
xfeed_1177 1 0 decap_w0
xfeed_1178 1 0 decap_w0
xfeed_1179 1 0 decap_w0
xfeed_27459 1 0 decap_w0
xfeed_27458 1 0 decap_w0
xfeed_27457 1 0 decap_w0
xfeed_27456 1 0 decap_w0
xfeed_27455 1 0 decap_w0
xfeed_27454 1 0 decap_w0
xfeed_27453 1 0 decap_w0
xfeed_27452 1 0 decap_w0
xfeed_27451 1 0 decap_w0
xfeed_27450 1 0 decap_w0
xfeed_26929 1 0 decap_w0
xfeed_26928 1 0 decap_w0
xfeed_26927 1 0 decap_w0
xfeed_26926 1 0 decap_w0
xfeed_26925 1 0 decap_w0
xfeed_26924 1 0 decap_w0
xfeed_26923 1 0 decap_w0
xfeed_26922 1 0 decap_w0
xfeed_26921 1 0 decap_w0
xfeed_26920 1 0 decap_w0
xfeed_23149 1 0 decap_w0
xfeed_22619 1 0 decap_w0
xfeed_22618 1 0 decap_w0
xfeed_22617 1 0 decap_w0
xfeed_22616 1 0 decap_w0
xfeed_22615 1 0 decap_w0
xfeed_22614 1 0 decap_w0
xfeed_22613 1 0 decap_w0
xfeed_22612 1 0 decap_w0
xfeed_22611 1 0 decap_w0
xfeed_22610 1 0 decap_w0
xfeed_17149 1 0 decap_w0
xfeed_17148 1 0 decap_w0
xfeed_17147 1 0 decap_w0
xfeed_17146 1 0 decap_w0
xfeed_17145 1 0 decap_w0
xfeed_17144 1 0 decap_w0
xfeed_17143 1 0 decap_w0
xfeed_17142 1 0 decap_w0
xfeed_17141 1 0 decap_w0
xfeed_17140 1 0 decap_w0
xfeed_16619 1 0 decap_w0
xfeed_16618 1 0 decap_w0
xfeed_16617 1 0 decap_w0
xfeed_16616 1 0 decap_w0
xfeed_16615 1 0 decap_w0
xfeed_16614 1 0 decap_w0
xfeed_16613 1 0 decap_w0
xfeed_16612 1 0 decap_w0
xfeed_16611 1 0 decap_w0
xfeed_16610 1 0 decap_w0
xfeed_12309 1 0 decap_w0
xfeed_12308 1 0 decap_w0
xfeed_12307 1 0 decap_w0
xfeed_12306 1 0 decap_w0
xfeed_12305 1 0 decap_w0
xfeed_12304 1 0 decap_w0
xfeed_12303 1 0 decap_w0
xfeed_12302 1 0 decap_w0
xfeed_12301 1 0 decap_w0
xfeed_12300 1 0 decap_w0
xfeed_11699 1 0 tie
xfeed_11698 1 0 decap_w0
xfeed_11697 1 0 decap_w0
xfeed_11696 1 0 decap_w0
xfeed_11695 1 0 decap_w0
xfeed_11694 1 0 decap_w0
xfeed_11693 1 0 decap_w0
xfeed_11692 1 0 decap_w0
xfeed_11691 1 0 decap_w0
xfeed_11690 1 0 decap_w0
xfeed_23155 1 0 decap_w0
xfeed_23154 1 0 decap_w0
xfeed_23153 1 0 decap_w0
xfeed_23152 1 0 decap_w0
xfeed_23151 1 0 decap_w0
xfeed_23150 1 0 decap_w0
xfeed_6109 1 0 decap_w0
xfeed_6108 1 0 decap_w0
xfeed_6107 1 0 decap_w0
xfeed_6106 1 0 decap_w0
xfeed_6105 1 0 decap_w0
xfeed_6104 1 0 decap_w0
xfeed_6103 1 0 decap_w0
xfeed_6102 1 0 decap_w0
xfeed_6101 1 0 decap_w0
xfeed_6100 1 0 decap_w0
xfeed_5499 1 0 decap_w0
xfeed_5498 1 0 decap_w0
xfeed_5497 1 0 decap_w0
xfeed_5496 1 0 decap_w0
xfeed_5495 1 0 decap_w0
xfeed_5494 1 0 decap_w0
xfeed_5493 1 0 decap_w0
xfeed_5492 1 0 decap_w0
xfeed_5491 1 0 decap_w0
xfeed_5490 1 0 decap_w0
xfeed_4969 1 0 decap_w0
xfeed_4968 1 0 decap_w0
xfeed_4967 1 0 decap_w0
xfeed_4966 1 0 decap_w0
xfeed_4965 1 0 decap_w0
xfeed_4964 1 0 decap_w0
xfeed_4963 1 0 decap_w0
xfeed_4962 1 0 decap_w0
xfeed_4961 1 0 decap_w0
xfeed_4960 1 0 decap_w0
xfeed_1180 1 0 decap_w0
xfeed_1181 1 0 decap_w0
xfeed_1182 1 0 decap_w0
xfeed_1183 1 0 decap_w0
xfeed_1184 1 0 decap_w0
xfeed_1185 1 0 decap_w0
xfeed_1186 1 0 decap_w0
xfeed_1187 1 0 decap_w0
xfeed_1188 1 0 decap_w0
xfeed_1189 1 0 decap_w0
xfeed_27469 1 0 decap_w0
xfeed_27468 1 0 decap_w0
xfeed_27467 1 0 decap_w0
xfeed_27466 1 0 decap_w0
xfeed_27465 1 0 decap_w0
xfeed_27464 1 0 decap_w0
xfeed_27463 1 0 decap_w0
xfeed_27462 1 0 decap_w0
xfeed_27461 1 0 decap_w0
xfeed_27460 1 0 decap_w0
xfeed_26939 1 0 decap_w0
xfeed_26938 1 0 decap_w0
xfeed_26937 1 0 decap_w0
xfeed_26936 1 0 decap_w0
xfeed_26935 1 0 decap_w0
xfeed_26934 1 0 decap_w0
xfeed_26933 1 0 decap_w0
xfeed_26932 1 0 decap_w0
xfeed_26931 1 0 decap_w0
xfeed_26930 1 0 decap_w0
xfeed_23159 1 0 decap_w0
xfeed_23158 1 0 decap_w0
xfeed_23157 1 0 decap_w0
xfeed_23156 1 0 decap_w0
xfeed_22629 1 0 decap_w0
xfeed_22628 1 0 decap_w0
xfeed_22627 1 0 decap_w0
xfeed_22626 1 0 decap_w0
xfeed_22625 1 0 decap_w0
xfeed_22624 1 0 decap_w0
xfeed_22623 1 0 decap_w0
xfeed_22622 1 0 decap_w0
xfeed_22621 1 0 decap_w0
xfeed_22620 1 0 decap_w0
xfeed_17159 1 0 decap_w0
xfeed_17158 1 0 decap_w0
xfeed_17157 1 0 decap_w0
xfeed_17156 1 0 decap_w0
xfeed_17155 1 0 decap_w0
xfeed_17154 1 0 decap_w0
xfeed_17153 1 0 decap_w0
xfeed_17152 1 0 decap_w0
xfeed_17151 1 0 decap_w0
xfeed_17150 1 0 decap_w0
xfeed_16629 1 0 decap_w0
xfeed_16628 1 0 decap_w0
xfeed_16627 1 0 decap_w0
xfeed_16626 1 0 decap_w0
xfeed_16625 1 0 decap_w0
xfeed_16624 1 0 decap_w0
xfeed_16623 1 0 decap_w0
xfeed_16622 1 0 decap_w0
xfeed_16621 1 0 decap_w0
xfeed_16620 1 0 decap_w0
xfeed_12319 1 0 decap_w0
xfeed_12318 1 0 decap_w0
xfeed_12317 1 0 decap_w0
xfeed_12316 1 0 decap_w0
xfeed_12315 1 0 decap_w0
xfeed_12314 1 0 decap_w0
xfeed_12313 1 0 decap_w0
xfeed_12312 1 0 decap_w0
xfeed_12311 1 0 decap_w0
xfeed_12310 1 0 decap_w0
xfeed_23162 1 0 decap_w0
xfeed_23161 1 0 decap_w0
xfeed_23160 1 0 decap_w0
xfeed_6119 1 0 decap_w0
xfeed_6118 1 0 decap_w0
xfeed_6117 1 0 decap_w0
xfeed_6116 1 0 decap_w0
xfeed_6115 1 0 decap_w0
xfeed_6114 1 0 decap_w0
xfeed_6113 1 0 decap_w0
xfeed_6112 1 0 decap_w0
xfeed_6111 1 0 decap_w0
xfeed_6110 1 0 decap_w0
xfeed_4979 1 0 decap_w0
xfeed_4978 1 0 decap_w0
xfeed_4977 1 0 decap_w0
xfeed_4976 1 0 decap_w0
xfeed_4975 1 0 decap_w0
xfeed_4974 1 0 decap_w0
xfeed_4973 1 0 decap_w0
xfeed_4972 1 0 decap_w0
xfeed_4971 1 0 decap_w0
xfeed_4970 1 0 decap_w0
xfeed_1190 1 0 decap_w0
xfeed_1191 1 0 decap_w0
xfeed_1192 1 0 decap_w0
xfeed_1193 1 0 decap_w0
xfeed_1194 1 0 decap_w0
xfeed_1195 1 0 decap_w0
xfeed_1196 1 0 decap_w0
xfeed_1197 1 0 decap_w0
xfeed_1198 1 0 decap_w0
xfeed_1199 1 0 decap_w0
xfeed_27479 1 0 decap_w0
xfeed_27478 1 0 decap_w0
xfeed_27477 1 0 decap_w0
xfeed_27476 1 0 decap_w0
xfeed_27475 1 0 decap_w0
xfeed_27474 1 0 decap_w0
xfeed_27473 1 0 decap_w0
xfeed_27472 1 0 decap_w0
xfeed_27471 1 0 decap_w0
xfeed_27470 1 0 decap_w0
xfeed_26949 1 0 decap_w0
xfeed_26948 1 0 decap_w0
xfeed_26947 1 0 decap_w0
xfeed_26946 1 0 decap_w0
xfeed_26945 1 0 decap_w0
xfeed_26944 1 0 decap_w0
xfeed_26943 1 0 decap_w0
xfeed_26942 1 0 decap_w0
xfeed_26941 1 0 decap_w0
xfeed_26940 1 0 decap_w0
xfeed_23169 1 0 decap_w0
xfeed_23168 1 0 decap_w0
xfeed_23167 1 0 decap_w0
xfeed_23166 1 0 decap_w0
xfeed_23165 1 0 decap_w0
xfeed_23164 1 0 decap_w0
xfeed_23163 1 0 decap_w0
xfeed_22639 1 0 decap_w0
xfeed_22638 1 0 decap_w0
xfeed_22637 1 0 decap_w0
xfeed_22636 1 0 decap_w0
xfeed_22635 1 0 decap_w0
xfeed_22634 1 0 decap_w0
xfeed_22633 1 0 decap_w0
xfeed_22632 1 0 decap_w0
xfeed_22631 1 0 decap_w0
xfeed_22630 1 0 decap_w0
xfeed_17169 1 0 decap_w0
xfeed_17168 1 0 decap_w0
xfeed_17167 1 0 decap_w0
xfeed_17166 1 0 decap_w0
xfeed_17165 1 0 decap_w0
xfeed_17164 1 0 decap_w0
xfeed_17163 1 0 decap_w0
xfeed_17162 1 0 decap_w0
xfeed_17161 1 0 decap_w0
xfeed_17160 1 0 decap_w0
xfeed_16639 1 0 decap_w0
xfeed_16638 1 0 decap_w0
xfeed_16637 1 0 decap_w0
xfeed_16636 1 0 decap_w0
xfeed_16635 1 0 decap_w0
xfeed_16634 1 0 decap_w0
xfeed_16633 1 0 decap_w0
xfeed_16632 1 0 decap_w0
xfeed_16631 1 0 decap_w0
xfeed_16630 1 0 decap_w0
xfeed_12329 1 0 decap_w0
xfeed_12328 1 0 decap_w0
xfeed_12327 1 0 decap_w0
xfeed_12326 1 0 decap_w0
xfeed_12325 1 0 decap_w0
xfeed_12324 1 0 decap_w0
xfeed_12323 1 0 decap_w0
xfeed_12322 1 0 decap_w0
xfeed_12321 1 0 decap_w0
xfeed_12320 1 0 decap_w0
xfeed_9909 1 0 decap_w0
xfeed_9908 1 0 decap_w0
xfeed_9907 1 0 decap_w0
xfeed_9906 1 0 decap_w0
xfeed_9905 1 0 decap_w0
xfeed_9904 1 0 decap_w0
xfeed_9903 1 0 decap_w0
xfeed_9902 1 0 decap_w0
xfeed_9901 1 0 decap_w0
xfeed_9900 1 0 decap_w0
xfeed_6129 1 0 decap_w0
xfeed_6128 1 0 decap_w0
xfeed_6127 1 0 decap_w0
xfeed_6126 1 0 decap_w0
xfeed_6125 1 0 decap_w0
xfeed_6124 1 0 decap_w0
xfeed_6123 1 0 decap_w0
xfeed_6122 1 0 decap_w0
xfeed_6121 1 0 decap_w0
xfeed_6120 1 0 decap_w0
xfeed_4989 1 0 decap_w0
xfeed_4988 1 0 decap_w0
xfeed_4987 1 0 decap_w0
xfeed_4986 1 0 decap_w0
xfeed_4985 1 0 decap_w0
xfeed_4984 1 0 decap_w0
xfeed_4983 1 0 decap_w0
xfeed_4982 1 0 decap_w0
xfeed_4981 1 0 decap_w0
xfeed_4980 1 0 decap_w0
xfeed_27489 1 0 decap_w0
xfeed_27488 1 0 decap_w0
xfeed_27487 1 0 decap_w0
xfeed_27486 1 0 decap_w0
xfeed_27485 1 0 decap_w0
xfeed_27484 1 0 decap_w0
xfeed_27483 1 0 decap_w0
xfeed_27482 1 0 decap_w0
xfeed_27481 1 0 decap_w0
xfeed_27480 1 0 decap_w0
xfeed_26959 1 0 decap_w0
xfeed_26958 1 0 decap_w0
xfeed_26957 1 0 decap_w0
xfeed_26956 1 0 decap_w0
xfeed_26955 1 0 decap_w0
xfeed_26954 1 0 decap_w0
xfeed_26953 1 0 decap_w0
xfeed_26952 1 0 decap_w0
xfeed_26951 1 0 decap_w0
xfeed_26950 1 0 decap_w0
xfeed_23179 1 0 decap_w0
xfeed_23178 1 0 decap_w0
xfeed_23177 1 0 decap_w0
xfeed_23176 1 0 decap_w0
xfeed_23175 1 0 decap_w0
xfeed_23174 1 0 decap_w0
xfeed_23173 1 0 decap_w0
xfeed_23172 1 0 decap_w0
xfeed_23171 1 0 decap_w0
xfeed_23170 1 0 decap_w0
xfeed_22649 1 0 decap_w0
xfeed_22648 1 0 decap_w0
xfeed_22647 1 0 decap_w0
xfeed_22646 1 0 decap_w0
xfeed_22645 1 0 decap_w0
xfeed_22644 1 0 decap_w0
xfeed_22643 1 0 decap_w0
xfeed_22642 1 0 decap_w0
xfeed_22641 1 0 decap_w0
xfeed_22640 1 0 decap_w0
xfeed_17179 1 0 decap_w0
xfeed_17178 1 0 decap_w0
xfeed_17177 1 0 decap_w0
xfeed_17176 1 0 decap_w0
xfeed_17175 1 0 decap_w0
xfeed_17174 1 0 decap_w0
xfeed_17173 1 0 decap_w0
xfeed_17172 1 0 decap_w0
xfeed_17171 1 0 decap_w0
xfeed_17170 1 0 decap_w0
xfeed_16649 1 0 decap_w0
xfeed_16648 1 0 decap_w0
xfeed_16647 1 0 decap_w0
xfeed_16646 1 0 decap_w0
xfeed_16645 1 0 decap_w0
xfeed_16644 1 0 decap_w0
xfeed_16643 1 0 decap_w0
xfeed_16642 1 0 decap_w0
xfeed_16641 1 0 decap_w0
xfeed_16640 1 0 decap_w0
xfeed_12339 1 0 decap_w0
xfeed_12338 1 0 decap_w0
xfeed_12337 1 0 decap_w0
xfeed_12336 1 0 decap_w0
xfeed_12335 1 0 decap_w0
xfeed_12334 1 0 decap_w0
xfeed_12333 1 0 decap_w0
xfeed_12332 1 0 decap_w0
xfeed_12331 1 0 decap_w0
xfeed_12330 1 0 decap_w0
xfeed_11809 1 0 decap_w0
xfeed_11808 1 0 decap_w0
xfeed_11807 1 0 decap_w0
xfeed_11806 1 0 decap_w0
xfeed_11805 1 0 decap_w0
xfeed_11804 1 0 decap_w0
xfeed_11803 1 0 decap_w0
xfeed_11802 1 0 decap_w0
xfeed_11801 1 0 decap_w0
xfeed_11800 1 0 decap_w0
xfeed_28109 1 0 decap_w0
xfeed_28108 1 0 decap_w0
xfeed_28107 1 0 decap_w0
xfeed_28106 1 0 decap_w0
xfeed_28105 1 0 decap_w0
xfeed_28104 1 0 decap_w0
xfeed_28103 1 0 decap_w0
xfeed_28102 1 0 decap_w0
xfeed_28101 1 0 decap_w0
xfeed_28100 1 0 decap_w0
xfeed_9919 1 0 decap_w0
xfeed_9918 1 0 decap_w0
xfeed_9917 1 0 decap_w0
xfeed_9916 1 0 decap_w0
xfeed_9915 1 0 decap_w0
xfeed_9914 1 0 decap_w0
xfeed_9913 1 0 decap_w0
xfeed_9912 1 0 decap_w0
xfeed_9911 1 0 decap_w0
xfeed_9910 1 0 decap_w0
xfeed_6139 1 0 decap_w0
xfeed_6138 1 0 decap_w0
xfeed_6137 1 0 decap_w0
xfeed_6136 1 0 decap_w0
xfeed_6135 1 0 decap_w0
xfeed_6134 1 0 decap_w0
xfeed_6133 1 0 decap_w0
xfeed_6132 1 0 decap_w0
xfeed_6131 1 0 decap_w0
xfeed_6130 1 0 decap_w0
xfeed_5609 1 0 decap_w0
xfeed_5608 1 0 decap_w0
xfeed_5607 1 0 decap_w0
xfeed_5606 1 0 decap_w0
xfeed_5605 1 0 decap_w0
xfeed_5604 1 0 decap_w0
xfeed_5603 1 0 decap_w0
xfeed_5602 1 0 decap_w0
xfeed_5601 1 0 decap_w0
xfeed_5600 1 0 decap_w0
xfeed_4999 1 0 decap_w0
xfeed_4998 1 0 decap_w0
xfeed_4997 1 0 decap_w0
xfeed_4996 1 0 decap_w0
xfeed_4995 1 0 decap_w0
xfeed_4994 1 0 decap_w0
xfeed_4993 1 0 decap_w0
xfeed_4992 1 0 decap_w0
xfeed_4991 1 0 decap_w0
xfeed_4990 1 0 decap_w0
xfeed_27499 1 0 decap_w0
xfeed_27498 1 0 decap_w0
xfeed_27497 1 0 decap_w0
xfeed_27496 1 0 decap_w0
xfeed_27495 1 0 decap_w0
xfeed_27494 1 0 decap_w0
xfeed_27493 1 0 decap_w0
xfeed_27492 1 0 decap_w0
xfeed_27491 1 0 decap_w0
xfeed_27490 1 0 decap_w0
xfeed_26969 1 0 decap_w0
xfeed_26968 1 0 decap_w0
xfeed_26967 1 0 decap_w0
xfeed_26966 1 0 decap_w0
xfeed_26965 1 0 decap_w0
xfeed_26964 1 0 decap_w0
xfeed_26963 1 0 decap_w0
xfeed_26962 1 0 decap_w0
xfeed_26961 1 0 decap_w0
xfeed_26960 1 0 decap_w0
xfeed_23189 1 0 decap_w0
xfeed_23188 1 0 decap_w0
xfeed_23187 1 0 decap_w0
xfeed_23186 1 0 decap_w0
xfeed_23185 1 0 decap_w0
xfeed_23184 1 0 decap_w0
xfeed_23183 1 0 decap_w0
xfeed_23182 1 0 decap_w0
xfeed_23181 1 0 decap_w0
xfeed_23180 1 0 decap_w0
xfeed_22659 1 0 decap_w0
xfeed_22658 1 0 decap_w0
xfeed_22657 1 0 decap_w0
xfeed_22656 1 0 decap_w0
xfeed_22655 1 0 decap_w0
xfeed_22654 1 0 decap_w0
xfeed_22653 1 0 decap_w0
xfeed_22652 1 0 decap_w0
xfeed_22651 1 0 decap_w0
xfeed_22650 1 0 decap_w0
xfeed_17189 1 0 decap_w0
xfeed_17188 1 0 decap_w0
xfeed_17187 1 0 decap_w0
xfeed_17186 1 0 decap_w0
xfeed_17185 1 0 tie
xfeed_17184 1 0 decap_w0
xfeed_17183 1 0 decap_w0
xfeed_17182 1 0 decap_w0
xfeed_17181 1 0 decap_w0
xfeed_17180 1 0 decap_w0
xfeed_16659 1 0 decap_w0
xfeed_16658 1 0 decap_w0
xfeed_16657 1 0 decap_w0
xfeed_16656 1 0 decap_w0
xfeed_16655 1 0 decap_w0
xfeed_16654 1 0 decap_w0
xfeed_16653 1 0 decap_w0
xfeed_16652 1 0 decap_w0
xfeed_16651 1 0 decap_w0
xfeed_16650 1 0 decap_w0
xfeed_12349 1 0 decap_w0
xfeed_12348 1 0 decap_w0
xfeed_12347 1 0 decap_w0
xfeed_12346 1 0 decap_w0
xfeed_12345 1 0 decap_w0
xfeed_12344 1 0 decap_w0
xfeed_12343 1 0 decap_w0
xfeed_12342 1 0 decap_w0
xfeed_12341 1 0 decap_w0
xfeed_12340 1 0 decap_w0
xfeed_11819 1 0 decap_w0
xfeed_11818 1 0 decap_w0
xfeed_11817 1 0 decap_w0
xfeed_11816 1 0 decap_w0
xfeed_11815 1 0 decap_w0
xfeed_11814 1 0 decap_w0
xfeed_11813 1 0 decap_w0
xfeed_11812 1 0 decap_w0
xfeed_11811 1 0 decap_w0
xfeed_11810 1 0 decap_w0
xfeed_28119 1 0 decap_w0
xfeed_28118 1 0 decap_w0
xfeed_28117 1 0 decap_w0
xfeed_28116 1 0 decap_w0
xfeed_28115 1 0 decap_w0
xfeed_28114 1 0 decap_w0
xfeed_28113 1 0 decap_w0
xfeed_28112 1 0 decap_w0
xfeed_28111 1 0 decap_w0
xfeed_28110 1 0 decap_w0
xfeed_9929 1 0 decap_w0
xfeed_9928 1 0 decap_w0
xfeed_9927 1 0 decap_w0
xfeed_9926 1 0 decap_w0
xfeed_9925 1 0 decap_w0
xfeed_9924 1 0 decap_w0
xfeed_9923 1 0 decap_w0
xfeed_9922 1 0 decap_w0
xfeed_9921 1 0 decap_w0
xfeed_9920 1 0 decap_w0
xfeed_6149 1 0 decap_w0
xfeed_6148 1 0 decap_w0
xfeed_6147 1 0 decap_w0
xfeed_6146 1 0 decap_w0
xfeed_6145 1 0 decap_w0
xfeed_6144 1 0 decap_w0
xfeed_6143 1 0 decap_w0
xfeed_6142 1 0 decap_w0
xfeed_6141 1 0 decap_w0
xfeed_6140 1 0 decap_w0
xfeed_5619 1 0 decap_w0
xfeed_5618 1 0 decap_w0
xfeed_5617 1 0 decap_w0
xfeed_5616 1 0 decap_w0
xfeed_5615 1 0 decap_w0
xfeed_5614 1 0 decap_w0
xfeed_5613 1 0 decap_w0
xfeed_5612 1 0 decap_w0
xfeed_5611 1 0 decap_w0
xfeed_5610 1 0 decap_w0
xfeed_1300 1 0 decap_w0
xfeed_1301 1 0 decap_w0
xfeed_1302 1 0 decap_w0
xfeed_1303 1 0 decap_w0
xfeed_1304 1 0 decap_w0
xfeed_1305 1 0 decap_w0
xfeed_1306 1 0 decap_w0
xfeed_1307 1 0 decap_w0
xfeed_1308 1 0 decap_w0
xfeed_1309 1 0 decap_w0
xfeed_26979 1 0 decap_w0
xfeed_26978 1 0 decap_w0
xfeed_26977 1 0 decap_w0
xfeed_26976 1 0 decap_w0
xfeed_26975 1 0 decap_w0
xfeed_26974 1 0 decap_w0
xfeed_26973 1 0 decap_w0
xfeed_26972 1 0 decap_w0
xfeed_26971 1 0 decap_w0
xfeed_26970 1 0 decap_w0
xfeed_23199 1 0 decap_w0
xfeed_23198 1 0 decap_w0
xfeed_23197 1 0 decap_w0
xfeed_23196 1 0 decap_w0
xfeed_23195 1 0 decap_w0
xfeed_23194 1 0 decap_w0
xfeed_23193 1 0 decap_w0
xfeed_23192 1 0 decap_w0
xfeed_23191 1 0 decap_w0
xfeed_23190 1 0 decap_w0
xfeed_22669 1 0 decap_w0
xfeed_22668 1 0 decap_w0
xfeed_22667 1 0 decap_w0
xfeed_22666 1 0 decap_w0
xfeed_22665 1 0 decap_w0
xfeed_22664 1 0 decap_w0
xfeed_22663 1 0 decap_w0
xfeed_22662 1 0 decap_w0
xfeed_22661 1 0 decap_w0
xfeed_22660 1 0 decap_w0
xfeed_17199 1 0 decap_w0
xfeed_17198 1 0 decap_w0
xfeed_17197 1 0 decap_w0
xfeed_17196 1 0 decap_w0
xfeed_17195 1 0 decap_w0
xfeed_17194 1 0 decap_w0
xfeed_17193 1 0 decap_w0
xfeed_17192 1 0 decap_w0
xfeed_17191 1 0 decap_w0
xfeed_17190 1 0 decap_w0
xfeed_16669 1 0 decap_w0
xfeed_16668 1 0 decap_w0
xfeed_16667 1 0 decap_w0
xfeed_16666 1 0 decap_w0
xfeed_16665 1 0 decap_w0
xfeed_16664 1 0 decap_w0
xfeed_16663 1 0 decap_w0
xfeed_16662 1 0 decap_w0
xfeed_16661 1 0 decap_w0
xfeed_16660 1 0 decap_w0
xfeed_12359 1 0 decap_w0
xfeed_12358 1 0 decap_w0
xfeed_12357 1 0 decap_w0
xfeed_12356 1 0 decap_w0
xfeed_12355 1 0 decap_w0
xfeed_12354 1 0 decap_w0
xfeed_12353 1 0 decap_w0
xfeed_12352 1 0 decap_w0
xfeed_12351 1 0 decap_w0
xfeed_12350 1 0 decap_w0
xfeed_11829 1 0 decap_w0
xfeed_11828 1 0 decap_w0
xfeed_11827 1 0 decap_w0
xfeed_11826 1 0 decap_w0
xfeed_11825 1 0 decap_w0
xfeed_11824 1 0 decap_w0
xfeed_11823 1 0 decap_w0
xfeed_11822 1 0 decap_w0
xfeed_11821 1 0 decap_w0
xfeed_11820 1 0 decap_w0
xfeed_28127 1 0 decap_w0
xfeed_28126 1 0 decap_w0
xfeed_28125 1 0 decap_w0
xfeed_28124 1 0 decap_w0
xfeed_28123 1 0 decap_w0
xfeed_28122 1 0 decap_w0
xfeed_28121 1 0 decap_w0
xfeed_28120 1 0 decap_w0
xfeed_9939 1 0 decap_w0
xfeed_9938 1 0 decap_w0
xfeed_9937 1 0 decap_w0
xfeed_9936 1 0 decap_w0
xfeed_9935 1 0 decap_w0
xfeed_9934 1 0 decap_w0
xfeed_9933 1 0 decap_w0
xfeed_9932 1 0 decap_w0
xfeed_9931 1 0 decap_w0
xfeed_9930 1 0 decap_w0
xfeed_6159 1 0 decap_w0
xfeed_6158 1 0 decap_w0
xfeed_6157 1 0 decap_w0
xfeed_6156 1 0 decap_w0
xfeed_6155 1 0 decap_w0
xfeed_6154 1 0 decap_w0
xfeed_6153 1 0 decap_w0
xfeed_6152 1 0 decap_w0
xfeed_6151 1 0 decap_w0
xfeed_6150 1 0 decap_w0
xfeed_5629 1 0 decap_w0
xfeed_5628 1 0 decap_w0
xfeed_5627 1 0 decap_w0
xfeed_5626 1 0 decap_w0
xfeed_5625 1 0 decap_w0
xfeed_5624 1 0 decap_w0
xfeed_5623 1 0 decap_w0
xfeed_5622 1 0 decap_w0
xfeed_5621 1 0 decap_w0
xfeed_5620 1 0 decap_w0
xfeed_1310 1 0 decap_w0
xfeed_1311 1 0 decap_w0
xfeed_1312 1 0 decap_w0
xfeed_1313 1 0 decap_w0
xfeed_1314 1 0 decap_w0
xfeed_1315 1 0 decap_w0
xfeed_1316 1 0 decap_w0
xfeed_1317 1 0 decap_w0
xfeed_1318 1 0 decap_w0
xfeed_1319 1 0 decap_w0
xfeed_28129 1 0 decap_w0
xfeed_28128 1 0 decap_w0
xfeed_26989 1 0 decap_w0
xfeed_26988 1 0 decap_w0
xfeed_26987 1 0 decap_w0
xfeed_26986 1 0 decap_w0
xfeed_26985 1 0 decap_w0
xfeed_26984 1 0 decap_w0
xfeed_26983 1 0 decap_w0
xfeed_26982 1 0 decap_w0
xfeed_26981 1 0 decap_w0
xfeed_26980 1 0 decap_w0
xfeed_22679 1 0 decap_w0
xfeed_22678 1 0 decap_w0
xfeed_22677 1 0 decap_w0
xfeed_22676 1 0 decap_w0
xfeed_22675 1 0 decap_w0
xfeed_22674 1 0 decap_w0
xfeed_22673 1 0 decap_w0
xfeed_22672 1 0 decap_w0
xfeed_22671 1 0 decap_w0
xfeed_22670 1 0 decap_w0
xfeed_16679 1 0 decap_w0
xfeed_16678 1 0 decap_w0
xfeed_16677 1 0 decap_w0
xfeed_16676 1 0 decap_w0
xfeed_16675 1 0 decap_w0
xfeed_16674 1 0 decap_w0
xfeed_16673 1 0 decap_w0
xfeed_16672 1 0 decap_w0
xfeed_16671 1 0 decap_w0
xfeed_16670 1 0 decap_w0
xfeed_12369 1 0 decap_w0
xfeed_12368 1 0 decap_w0
xfeed_12367 1 0 decap_w0
xfeed_12366 1 0 decap_w0
xfeed_12365 1 0 decap_w0
xfeed_12364 1 0 decap_w0
xfeed_12363 1 0 decap_w0
xfeed_12362 1 0 decap_w0
xfeed_12361 1 0 decap_w0
xfeed_12360 1 0 decap_w0
xfeed_11839 1 0 decap_w0
xfeed_11838 1 0 decap_w0
xfeed_11837 1 0 decap_w0
xfeed_11836 1 0 decap_w0
xfeed_11835 1 0 decap_w0
xfeed_11834 1 0 decap_w0
xfeed_11833 1 0 decap_w0
xfeed_11832 1 0 decap_w0
xfeed_11831 1 0 decap_w0
xfeed_11830 1 0 decap_w0
xsubckt_41_xor2_x0 1 0 40 49 181 xor2_x0
xfeed_28134 1 0 decap_w0
xfeed_28133 1 0 decap_w0
xfeed_28132 1 0 decap_w0
xfeed_28131 1 0 decap_w0
xfeed_28130 1 0 decap_w0
xfeed_9949 1 0 decap_w0
xfeed_9948 1 0 decap_w0
xfeed_9947 1 0 decap_w0
xfeed_9946 1 0 decap_w0
xfeed_9945 1 0 decap_w0
xfeed_9944 1 0 decap_w0
xfeed_9943 1 0 decap_w0
xfeed_9942 1 0 decap_w0
xfeed_9941 1 0 decap_w0
xfeed_9940 1 0 decap_w0
xfeed_6169 1 0 decap_w0
xfeed_6168 1 0 decap_w0
xfeed_6167 1 0 decap_w0
xfeed_6166 1 0 decap_w0
xfeed_6165 1 0 decap_w0
xfeed_6164 1 0 decap_w0
xfeed_6163 1 0 decap_w0
xfeed_6162 1 0 decap_w0
xfeed_6161 1 0 decap_w0
xfeed_6160 1 0 decap_w0
xfeed_5639 1 0 decap_w0
xfeed_5638 1 0 decap_w0
xfeed_5637 1 0 decap_w0
xfeed_5636 1 0 decap_w0
xfeed_5635 1 0 decap_w0
xfeed_5634 1 0 decap_w0
xfeed_5633 1 0 decap_w0
xfeed_5632 1 0 decap_w0
xfeed_5631 1 0 decap_w0
xfeed_5630 1 0 decap_w0
xsubckt_37_xor2_x0 1 0 45 54 184 xor2_x0
xfeed_1320 1 0 decap_w0
xfeed_1321 1 0 decap_w0
xfeed_1322 1 0 decap_w0
xfeed_1323 1 0 decap_w0
xfeed_1324 1 0 decap_w0
xfeed_1325 1 0 decap_w0
xfeed_1326 1 0 decap_w0
xfeed_1327 1 0 decap_w0
xfeed_1328 1 0 decap_w0
xfeed_1329 1 0 decap_w0
xfeed_28139 1 0 decap_w0
xfeed_28138 1 0 decap_w0
xfeed_28137 1 0 decap_w0
xfeed_28136 1 0 decap_w0
xfeed_28135 1 0 decap_w0
xfeed_27609 1 0 decap_w0
xfeed_27608 1 0 decap_w0
xfeed_27607 1 0 decap_w0
xfeed_27606 1 0 decap_w0
xfeed_27605 1 0 decap_w0
xfeed_27604 1 0 decap_w0
xfeed_27603 1 0 decap_w0
xfeed_27602 1 0 decap_w0
xfeed_27601 1 0 decap_w0
xfeed_27600 1 0 decap_w0
xfeed_26999 1 0 decap_w0
xfeed_26998 1 0 decap_w0
xfeed_26997 1 0 decap_w0
xfeed_26996 1 0 decap_w0
xfeed_26995 1 0 decap_w0
xfeed_26994 1 0 decap_w0
xfeed_26993 1 0 decap_w0
xfeed_26992 1 0 decap_w0
xfeed_26991 1 0 decap_w0
xfeed_26990 1 0 decap_w0
xfeed_22689 1 0 decap_w0
xfeed_22688 1 0 decap_w0
xfeed_22687 1 0 decap_w0
xfeed_22686 1 0 decap_w0
xfeed_22685 1 0 decap_w0
xfeed_22684 1 0 decap_w0
xfeed_22683 1 0 decap_w0
xfeed_22682 1 0 decap_w0
xfeed_22681 1 0 decap_w0
xfeed_22680 1 0 decap_w0
xfeed_16689 1 0 decap_w0
xfeed_16688 1 0 decap_w0
xfeed_16687 1 0 decap_w0
xfeed_16686 1 0 decap_w0
xfeed_16685 1 0 decap_w0
xfeed_16684 1 0 decap_w0
xfeed_16683 1 0 decap_w0
xfeed_16682 1 0 decap_w0
xfeed_16681 1 0 decap_w0
xfeed_16680 1 0 decap_w0
xfeed_12379 1 0 decap_w0
xfeed_12378 1 0 decap_w0
xfeed_12377 1 0 decap_w0
xfeed_12376 1 0 decap_w0
xfeed_12375 1 0 decap_w0
xfeed_12374 1 0 decap_w0
xfeed_12373 1 0 decap_w0
xfeed_12372 1 0 decap_w0
xfeed_12371 1 0 decap_w0
xfeed_12370 1 0 decap_w0
xfeed_11849 1 0 decap_w0
xfeed_11848 1 0 decap_w0
xfeed_11847 1 0 decap_w0
xfeed_11846 1 0 decap_w0
xfeed_11845 1 0 decap_w0
xfeed_11844 1 0 decap_w0
xfeed_11843 1 0 decap_w0
xfeed_11842 1 0 decap_w0
xfeed_11841 1 0 decap_w0
xfeed_11840 1 0 decap_w0
xfeed_28141 1 0 decap_w0
xfeed_28140 1 0 decap_w0
xfeed_23302 1 0 decap_w0
xfeed_23301 1 0 decap_w0
xfeed_23300 1 0 decap_w0
xfeed_9959 1 0 decap_w0
xfeed_9958 1 0 decap_w0
xfeed_9957 1 0 decap_w0
xfeed_9956 1 0 decap_w0
xfeed_9955 1 0 decap_w0
xfeed_9954 1 0 decap_w0
xfeed_9953 1 0 decap_w0
xfeed_9952 1 0 decap_w0
xfeed_9951 1 0 decap_w0
xfeed_9950 1 0 decap_w0
xfeed_6179 1 0 decap_w0
xfeed_6178 1 0 decap_w0
xfeed_6177 1 0 decap_w0
xfeed_6176 1 0 decap_w0
xfeed_6175 1 0 decap_w0
xfeed_6174 1 0 decap_w0
xfeed_6173 1 0 decap_w0
xfeed_6172 1 0 decap_w0
xfeed_6171 1 0 decap_w0
xfeed_6170 1 0 decap_w0
xfeed_5649 1 0 decap_w0
xfeed_5648 1 0 decap_w0
xfeed_5647 1 0 decap_w0
xfeed_5646 1 0 decap_w0
xfeed_5645 1 0 decap_w0
xfeed_5644 1 0 decap_w0
xfeed_5643 1 0 decap_w0
xfeed_5642 1 0 decap_w0
xfeed_5641 1 0 decap_w0
xfeed_5640 1 0 decap_w0
xfeed_1330 1 0 decap_w0
xfeed_1331 1 0 decap_w0
xfeed_1332 1 0 decap_w0
xfeed_1333 1 0 decap_w0
xfeed_1334 1 0 decap_w0
xfeed_1335 1 0 decap_w0
xfeed_1336 1 0 decap_w0
xfeed_1337 1 0 decap_w0
xfeed_1338 1 0 decap_w0
xfeed_1339 1 0 decap_w0
xfeed_28149 1 0 decap_w0
xfeed_28148 1 0 decap_w0
xfeed_28147 1 0 decap_w0
xfeed_28146 1 0 decap_w0
xfeed_28145 1 0 decap_w0
xfeed_28144 1 0 decap_w0
xfeed_28143 1 0 decap_w0
xfeed_28142 1 0 decap_w0
xfeed_27619 1 0 decap_w0
xfeed_27618 1 0 decap_w0
xfeed_27617 1 0 decap_w0
xfeed_27616 1 0 decap_w0
xfeed_27615 1 0 decap_w0
xfeed_27614 1 0 decap_w0
xfeed_27613 1 0 decap_w0
xfeed_27612 1 0 decap_w0
xfeed_27611 1 0 decap_w0
xfeed_27610 1 0 decap_w0
xfeed_23309 1 0 decap_w0
xfeed_23308 1 0 decap_w0
xfeed_23307 1 0 decap_w0
xfeed_23306 1 0 decap_w0
xfeed_23305 1 0 decap_w0
xfeed_23304 1 0 decap_w0
xfeed_23303 1 0 decap_w0
xfeed_22699 1 0 decap_w0
xfeed_22698 1 0 decap_w0
xfeed_22697 1 0 decap_w0
xfeed_22696 1 0 decap_w0
xfeed_22695 1 0 decap_w0
xfeed_22694 1 0 decap_w0
xfeed_22693 1 0 decap_w0
xfeed_22692 1 0 decap_w0
xfeed_22691 1 0 decap_w0
xfeed_22690 1 0 decap_w0
xfeed_17309 1 0 decap_w0
xfeed_17308 1 0 decap_w0
xfeed_17307 1 0 decap_w0
xfeed_17306 1 0 decap_w0
xfeed_17305 1 0 decap_w0
xfeed_17304 1 0 decap_w0
xfeed_17303 1 0 decap_w0
xfeed_17302 1 0 decap_w0
xfeed_17301 1 0 decap_w0
xfeed_17300 1 0 tie
xfeed_16699 1 0 decap_w0
xfeed_16698 1 0 decap_w0
xfeed_16697 1 0 decap_w0
xfeed_16696 1 0 decap_w0
xfeed_16695 1 0 decap_w0
xfeed_16694 1 0 decap_w0
xfeed_16693 1 0 decap_w0
xfeed_16692 1 0 decap_w0
xfeed_16691 1 0 decap_w0
xfeed_16690 1 0 decap_w0
xfeed_12389 1 0 decap_w0
xfeed_12388 1 0 decap_w0
xfeed_12387 1 0 decap_w0
xfeed_12386 1 0 decap_w0
xfeed_12385 1 0 decap_w0
xfeed_12384 1 0 decap_w0
xfeed_12383 1 0 decap_w0
xfeed_12382 1 0 decap_w0
xfeed_12381 1 0 decap_w0
xfeed_12380 1 0 decap_w0
xfeed_11859 1 0 decap_w0
xfeed_11858 1 0 decap_w0
xfeed_11857 1 0 decap_w0
xfeed_11856 1 0 decap_w0
xfeed_11855 1 0 decap_w0
xfeed_11854 1 0 decap_w0
xfeed_11853 1 0 decap_w0
xfeed_11852 1 0 decap_w0
xfeed_11851 1 0 decap_w0
xfeed_11850 1 0 decap_w0
xfeed_9969 1 0 decap_w0
xfeed_9968 1 0 decap_w0
xfeed_9967 1 0 decap_w0
xfeed_9966 1 0 decap_w0
xfeed_9965 1 0 decap_w0
xfeed_9964 1 0 tie
xfeed_9963 1 0 decap_w0
xfeed_9962 1 0 decap_w0
xfeed_9961 1 0 decap_w0
xfeed_9960 1 0 decap_w0
xfeed_6189 1 0 decap_w0
xfeed_6188 1 0 decap_w0
xfeed_6187 1 0 decap_w0
xfeed_6186 1 0 decap_w0
xfeed_6185 1 0 decap_w0
xfeed_6184 1 0 decap_w0
xfeed_6183 1 0 decap_w0
xfeed_6182 1 0 decap_w0
xfeed_6181 1 0 decap_w0
xfeed_6180 1 0 decap_w0
xfeed_5659 1 0 decap_w0
xfeed_5658 1 0 decap_w0
xfeed_5657 1 0 decap_w0
xfeed_5656 1 0 decap_w0
xfeed_5655 1 0 decap_w0
xfeed_5654 1 0 decap_w0
xfeed_5653 1 0 decap_w0
xfeed_5652 1 0 decap_w0
xfeed_5651 1 0 decap_w0
xfeed_5650 1 0 decap_w0
xfeed_1340 1 0 decap_w0
xfeed_1341 1 0 decap_w0
xfeed_1342 1 0 decap_w0
xfeed_1343 1 0 decap_w0
xfeed_1344 1 0 decap_w0
xfeed_1345 1 0 decap_w0
xfeed_1346 1 0 decap_w0
xfeed_1347 1 0 decap_w0
xfeed_1348 1 0 decap_w0
xfeed_1349 1 0 decap_w0
xfeed_28159 1 0 decap_w0
xfeed_28158 1 0 decap_w0
xfeed_28157 1 0 decap_w0
xfeed_28156 1 0 decap_w0
xfeed_28155 1 0 decap_w0
xfeed_28154 1 0 decap_w0
xfeed_28153 1 0 decap_w0
xfeed_28152 1 0 decap_w0
xfeed_28151 1 0 decap_w0
xfeed_28150 1 0 decap_w0
xfeed_27629 1 0 decap_w0
xfeed_27628 1 0 decap_w0
xfeed_27627 1 0 decap_w0
xfeed_27626 1 0 decap_w0
xfeed_27625 1 0 decap_w0
xfeed_27624 1 0 decap_w0
xfeed_27623 1 0 decap_w0
xfeed_27622 1 0 decap_w0
xfeed_27621 1 0 decap_w0
xfeed_27620 1 0 decap_w0
xfeed_23319 1 0 decap_w0
xfeed_23318 1 0 decap_w0
xfeed_23317 1 0 decap_w0
xfeed_23316 1 0 decap_w0
xfeed_23315 1 0 decap_w0
xfeed_23314 1 0 decap_w0
xfeed_23313 1 0 decap_w0
xfeed_23312 1 0 decap_w0
xfeed_23311 1 0 decap_w0
xfeed_23310 1 0 decap_w0
xfeed_17319 1 0 decap_w0
xfeed_17318 1 0 decap_w0
xfeed_17317 1 0 decap_w0
xfeed_17316 1 0 decap_w0
xfeed_17315 1 0 decap_w0
xfeed_17314 1 0 decap_w0
xfeed_17313 1 0 decap_w0
xfeed_17312 1 0 decap_w0
xfeed_17311 1 0 decap_w0
xfeed_17310 1 0 decap_w0
xfeed_13009 1 0 decap_w0
xfeed_13008 1 0 decap_w0
xfeed_13007 1 0 decap_w0
xfeed_13006 1 0 decap_w0
xfeed_13005 1 0 decap_w0
xfeed_13004 1 0 decap_w0
xfeed_13003 1 0 decap_w0
xfeed_13002 1 0 decap_w0
xfeed_13001 1 0 decap_w0
xfeed_13000 1 0 decap_w0
xfeed_12399 1 0 decap_w0
xfeed_12398 1 0 decap_w0
xfeed_12397 1 0 decap_w0
xfeed_12396 1 0 decap_w0
xfeed_12395 1 0 decap_w0
xfeed_12394 1 0 decap_w0
xfeed_12393 1 0 decap_w0
xfeed_12392 1 0 decap_w0
xfeed_12391 1 0 decap_w0
xfeed_12390 1 0 decap_w0
xfeed_11869 1 0 decap_w0
xfeed_11868 1 0 decap_w0
xfeed_11867 1 0 decap_w0
xfeed_11866 1 0 decap_w0
xfeed_11865 1 0 decap_w0
xfeed_11864 1 0 decap_w0
xfeed_11863 1 0 decap_w0
xfeed_11862 1 0 decap_w0
xfeed_11861 1 0 decap_w0
xfeed_11860 1 0 decap_w0
xfeed_9979 1 0 decap_w0
xfeed_9978 1 0 decap_w0
xfeed_9977 1 0 decap_w0
xfeed_9976 1 0 decap_w0
xfeed_9975 1 0 decap_w0
xfeed_9974 1 0 decap_w0
xfeed_9973 1 0 decap_w0
xfeed_9972 1 0 decap_w0
xfeed_9971 1 0 decap_w0
xfeed_9970 1 0 decap_w0
xfeed_6199 1 0 decap_w0
xfeed_6198 1 0 decap_w0
xfeed_6197 1 0 decap_w0
xfeed_6196 1 0 decap_w0
xfeed_6195 1 0 decap_w0
xfeed_6194 1 0 decap_w0
xfeed_6193 1 0 decap_w0
xfeed_6192 1 0 decap_w0
xfeed_6191 1 0 decap_w0
xfeed_6190 1 0 decap_w0
xfeed_5669 1 0 decap_w0
xfeed_5668 1 0 decap_w0
xfeed_5667 1 0 decap_w0
xfeed_5666 1 0 decap_w0
xfeed_5665 1 0 decap_w0
xfeed_5664 1 0 decap_w0
xfeed_5663 1 0 decap_w0
xfeed_5662 1 0 decap_w0
xfeed_5661 1 0 decap_w0
xfeed_5660 1 0 decap_w0
xfeed_1350 1 0 decap_w0
xfeed_1351 1 0 decap_w0
xfeed_1352 1 0 decap_w0
xfeed_1353 1 0 decap_w0
xfeed_1354 1 0 decap_w0
xfeed_1355 1 0 decap_w0
xfeed_1356 1 0 decap_w0
xfeed_1357 1 0 decap_w0
xfeed_1358 1 0 decap_w0
xfeed_1359 1 0 decap_w0
xfeed_28169 1 0 decap_w0
xfeed_28168 1 0 decap_w0
xfeed_28167 1 0 decap_w0
xfeed_28166 1 0 decap_w0
xfeed_28165 1 0 decap_w0
xfeed_28164 1 0 decap_w0
xfeed_28163 1 0 decap_w0
xfeed_28162 1 0 decap_w0
xfeed_28161 1 0 decap_w0
xfeed_28160 1 0 decap_w0
xfeed_27639 1 0 decap_w0
xfeed_27638 1 0 decap_w0
xfeed_27637 1 0 decap_w0
xfeed_27636 1 0 decap_w0
xfeed_27635 1 0 decap_w0
xfeed_27634 1 0 decap_w0
xfeed_27633 1 0 decap_w0
xfeed_27632 1 0 decap_w0
xfeed_27631 1 0 decap_w0
xfeed_27630 1 0 decap_w0
xfeed_23329 1 0 decap_w0
xfeed_23328 1 0 decap_w0
xfeed_23327 1 0 decap_w0
xfeed_23326 1 0 decap_w0
xfeed_23325 1 0 decap_w0
xfeed_23324 1 0 decap_w0
xfeed_23323 1 0 decap_w0
xfeed_23322 1 0 decap_w0
xfeed_23321 1 0 decap_w0
xfeed_23320 1 0 decap_w0
xfeed_17329 1 0 decap_w0
xfeed_17328 1 0 decap_w0
xfeed_17327 1 0 decap_w0
xfeed_17326 1 0 decap_w0
xfeed_17325 1 0 decap_w0
xfeed_17324 1 0 decap_w0
xfeed_17323 1 0 decap_w0
xfeed_17322 1 0 decap_w0
xfeed_17321 1 0 decap_w0
xfeed_17320 1 0 decap_w0
xfeed_13019 1 0 decap_w0
xfeed_13018 1 0 decap_w0
xfeed_13017 1 0 decap_w0
xfeed_13016 1 0 decap_w0
xfeed_13015 1 0 decap_w0
xfeed_13014 1 0 decap_w0
xfeed_13013 1 0 decap_w0
xfeed_13012 1 0 decap_w0
xfeed_13011 1 0 decap_w0
xfeed_13010 1 0 decap_w0
xfeed_11877 1 0 decap_w0
xfeed_11876 1 0 decap_w0
xfeed_11875 1 0 decap_w0
xfeed_11874 1 0 decap_w0
xfeed_11873 1 0 decap_w0
xfeed_11872 1 0 decap_w0
xfeed_11871 1 0 tie
xfeed_11870 1 0 decap_w0
xfeed_11879 1 0 decap_w0
xfeed_11878 1 0 decap_w0
xfeed_9989 1 0 decap_w0
xfeed_9988 1 0 decap_w0
xfeed_9987 1 0 decap_w0
xfeed_9986 1 0 decap_w0
xfeed_9985 1 0 decap_w0
xfeed_9984 1 0 decap_w0
xfeed_9983 1 0 decap_w0
xfeed_9982 1 0 decap_w0
xfeed_9981 1 0 decap_w0
xfeed_9980 1 0 decap_w0
xfeed_5679 1 0 decap_w0
xfeed_5678 1 0 decap_w0
xfeed_5677 1 0 decap_w0
xfeed_5676 1 0 decap_w0
xfeed_5675 1 0 decap_w0
xfeed_5674 1 0 decap_w0
xfeed_5673 1 0 decap_w0
xfeed_5672 1 0 decap_w0
xfeed_5671 1 0 decap_w0
xfeed_5670 1 0 decap_w0
xfeed_1360 1 0 decap_w0
xfeed_1361 1 0 decap_w0
xfeed_1362 1 0 decap_w0
xfeed_1363 1 0 decap_w0
xfeed_1364 1 0 decap_w0
xfeed_1365 1 0 decap_w0
xfeed_1366 1 0 decap_w0
xfeed_1367 1 0 decap_w0
xfeed_1368 1 0 decap_w0
xfeed_1369 1 0 decap_w0
xfeed_28179 1 0 decap_w0
xfeed_28178 1 0 decap_w0
xfeed_28177 1 0 decap_w0
xfeed_28176 1 0 decap_w0
xfeed_28175 1 0 decap_w0
xfeed_28174 1 0 decap_w0
xfeed_28173 1 0 decap_w0
xfeed_28172 1 0 decap_w0
xfeed_28171 1 0 decap_w0
xfeed_28170 1 0 decap_w0
xfeed_27649 1 0 decap_w0
xfeed_27648 1 0 decap_w0
xfeed_27647 1 0 decap_w0
xfeed_27646 1 0 decap_w0
xfeed_27645 1 0 decap_w0
xfeed_27644 1 0 decap_w0
xfeed_27643 1 0 decap_w0
xfeed_27642 1 0 decap_w0
xfeed_27641 1 0 decap_w0
xfeed_27640 1 0 decap_w0
xfeed_23339 1 0 decap_w0
xfeed_23338 1 0 decap_w0
xfeed_23337 1 0 decap_w0
xfeed_23336 1 0 decap_w0
xfeed_23335 1 0 decap_w0
xfeed_23334 1 0 decap_w0
xfeed_23333 1 0 decap_w0
xfeed_23332 1 0 decap_w0
xfeed_23331 1 0 decap_w0
xfeed_23330 1 0 decap_w0
xfeed_22809 1 0 decap_w0
xfeed_22808 1 0 decap_w0
xfeed_22807 1 0 decap_w0
xfeed_22806 1 0 decap_w0
xfeed_22805 1 0 decap_w0
xfeed_22804 1 0 decap_w0
xfeed_22803 1 0 decap_w0
xfeed_22802 1 0 decap_w0
xfeed_22801 1 0 decap_w0
xfeed_22800 1 0 decap_w0
xfeed_17339 1 0 decap_w0
xfeed_17338 1 0 decap_w0
xfeed_17337 1 0 decap_w0
xfeed_17336 1 0 decap_w0
xfeed_17335 1 0 decap_w0
xfeed_17334 1 0 decap_w0
xfeed_17333 1 0 decap_w0
xfeed_17332 1 0 decap_w0
xfeed_17331 1 0 decap_w0
xfeed_17330 1 0 decap_w0
xfeed_16809 1 0 decap_w0
xfeed_16808 1 0 decap_w0
xfeed_16807 1 0 decap_w0
xfeed_16806 1 0 decap_w0
xfeed_16805 1 0 decap_w0
xfeed_16804 1 0 decap_w0
xfeed_16803 1 0 decap_w0
xfeed_16802 1 0 decap_w0
xfeed_16801 1 0 decap_w0
xfeed_16800 1 0 decap_w0
xfeed_13029 1 0 decap_w0
xfeed_13028 1 0 decap_w0
xfeed_13027 1 0 decap_w0
xfeed_13026 1 0 decap_w0
xfeed_13025 1 0 decap_w0
xfeed_13024 1 0 decap_w0
xfeed_13023 1 0 decap_w0
xfeed_13022 1 0 decap_w0
xfeed_13021 1 0 decap_w0
xfeed_13020 1 0 decap_w0
xfeed_11884 1 0 decap_w0
xfeed_11883 1 0 decap_w0
xfeed_11882 1 0 decap_w0
xfeed_11881 1 0 decap_w0
xfeed_11880 1 0 decap_w0
xfeed_11889 1 0 decap_w0
xfeed_11888 1 0 decap_w0
xfeed_11887 1 0 decap_w0
xfeed_11886 1 0 decap_w0
xfeed_11885 1 0 decap_w0
xfeed_9999 1 0 decap_w0
xfeed_9998 1 0 decap_w0
xfeed_9997 1 0 decap_w0
xfeed_9996 1 0 decap_w0
xfeed_9995 1 0 decap_w0
xfeed_9994 1 0 decap_w0
xfeed_9993 1 0 decap_w0
xfeed_9992 1 0 decap_w0
xfeed_9991 1 0 decap_w0
xfeed_9990 1 0 decap_w0
xfeed_5689 1 0 decap_w0
xfeed_5688 1 0 decap_w0
xfeed_5687 1 0 decap_w0
xfeed_5686 1 0 decap_w0
xfeed_5685 1 0 decap_w0
xfeed_5684 1 0 decap_w0
xfeed_5683 1 0 decap_w0
xfeed_5682 1 0 decap_w0
xfeed_5681 1 0 decap_w0
xfeed_5680 1 0 decap_w0
xfeed_1370 1 0 decap_w0
xfeed_1371 1 0 decap_w0
xfeed_1372 1 0 decap_w0
xfeed_1373 1 0 decap_w0
xfeed_1374 1 0 decap_w0
xfeed_1375 1 0 decap_w0
xfeed_1376 1 0 decap_w0
xfeed_1377 1 0 decap_w0
xfeed_1378 1 0 decap_w0
xfeed_1379 1 0 decap_w0
xfeed_28189 1 0 decap_w0
xfeed_28188 1 0 decap_w0
xfeed_28187 1 0 decap_w0
xfeed_28186 1 0 decap_w0
xfeed_28185 1 0 decap_w0
xfeed_28184 1 0 decap_w0
xfeed_28183 1 0 decap_w0
xfeed_28182 1 0 decap_w0
xfeed_28181 1 0 decap_w0
xfeed_28180 1 0 decap_w0
xfeed_27659 1 0 decap_w0
xfeed_27658 1 0 decap_w0
xfeed_27657 1 0 decap_w0
xfeed_27656 1 0 decap_w0
xfeed_27655 1 0 decap_w0
xfeed_27654 1 0 decap_w0
xfeed_27653 1 0 decap_w0
xfeed_27652 1 0 decap_w0
xfeed_27651 1 0 decap_w0
xfeed_27650 1 0 decap_w0
xfeed_23349 1 0 decap_w0
xfeed_23348 1 0 decap_w0
xfeed_23347 1 0 decap_w0
xfeed_23346 1 0 decap_w0
xfeed_23345 1 0 decap_w0
xfeed_23344 1 0 decap_w0
xfeed_23343 1 0 decap_w0
xfeed_23342 1 0 decap_w0
xfeed_23341 1 0 decap_w0
xfeed_23340 1 0 decap_w0
xfeed_22819 1 0 decap_w0
xfeed_22818 1 0 decap_w0
xfeed_22817 1 0 decap_w0
xfeed_22816 1 0 decap_w0
xfeed_22815 1 0 decap_w0
xfeed_22814 1 0 decap_w0
xfeed_22813 1 0 decap_w0
xfeed_22812 1 0 decap_w0
xfeed_22811 1 0 decap_w0
xfeed_22810 1 0 decap_w0
xfeed_17349 1 0 decap_w0
xfeed_17348 1 0 decap_w0
xfeed_17347 1 0 decap_w0
xfeed_17346 1 0 decap_w0
xfeed_17345 1 0 decap_w0
xfeed_17344 1 0 decap_w0
xfeed_17343 1 0 decap_w0
xfeed_17342 1 0 decap_w0
xfeed_17341 1 0 decap_w0
xfeed_17340 1 0 decap_w0
xfeed_16819 1 0 decap_w0
xfeed_16818 1 0 decap_w0
xfeed_16817 1 0 decap_w0
xfeed_16816 1 0 decap_w0
xfeed_16815 1 0 decap_w0
xfeed_16814 1 0 decap_w0
xfeed_16813 1 0 decap_w0
xfeed_16812 1 0 decap_w0
xfeed_16811 1 0 decap_w0
xfeed_16810 1 0 decap_w0
xfeed_13039 1 0 decap_w0
xfeed_13038 1 0 decap_w0
xfeed_13037 1 0 decap_w0
xfeed_13036 1 0 decap_w0
xfeed_13035 1 0 decap_w0
xfeed_13034 1 0 decap_w0
xfeed_13033 1 0 decap_w0
xfeed_13032 1 0 decap_w0
xfeed_13031 1 0 decap_w0
xfeed_13030 1 0 decap_w0
xfeed_12509 1 0 decap_w0
xfeed_12508 1 0 decap_w0
xfeed_12507 1 0 decap_w0
xfeed_12506 1 0 decap_w0
xfeed_12505 1 0 decap_w0
xfeed_12504 1 0 decap_w0
xfeed_12503 1 0 decap_w0
xfeed_12502 1 0 decap_w0
xfeed_12501 1 0 decap_w0
xfeed_12500 1 0 decap_w0
xfeed_11891 1 0 decap_w0
xfeed_11890 1 0 decap_w0
xsubckt_96_xor2_x0 1 0 39 48 142 xor2_x0
xfeed_11899 1 0 decap_w0
xfeed_11898 1 0 decap_w0
xfeed_11897 1 0 decap_w0
xfeed_11896 1 0 decap_w0
xfeed_11895 1 0 decap_w0
xfeed_11894 1 0 decap_w0
xfeed_11893 1 0 decap_w0
xfeed_11892 1 0 decap_w0
xfeed_6309 1 0 decap_w0
xfeed_6308 1 0 decap_w0
xfeed_6307 1 0 decap_w0
xfeed_6306 1 0 decap_w0
xfeed_6305 1 0 decap_w0
xfeed_6304 1 0 decap_w0
xfeed_6303 1 0 decap_w0
xfeed_6302 1 0 decap_w0
xfeed_6301 1 0 decap_w0
xfeed_6300 1 0 decap_w0
xfeed_5699 1 0 decap_w0
xfeed_5698 1 0 decap_w0
xfeed_5697 1 0 decap_w0
xfeed_5696 1 0 decap_w0
xfeed_5695 1 0 decap_w0
xfeed_5694 1 0 decap_w0
xfeed_5693 1 0 decap_w0
xfeed_5692 1 0 decap_w0
xfeed_5691 1 0 decap_w0
xfeed_5690 1 0 decap_w0
xfeed_1380 1 0 decap_w0
xfeed_1381 1 0 decap_w0
xfeed_1382 1 0 decap_w0
xfeed_1383 1 0 decap_w0
xfeed_1384 1 0 decap_w0
xfeed_1385 1 0 decap_w0
xfeed_1386 1 0 decap_w0
xfeed_1387 1 0 decap_w0
xfeed_1388 1 0 decap_w0
xfeed_1389 1 0 decap_w0
xfeed_28199 1 0 decap_w0
xfeed_28198 1 0 decap_w0
xfeed_28197 1 0 decap_w0
xfeed_28196 1 0 decap_w0
xfeed_28195 1 0 decap_w0
xfeed_28194 1 0 decap_w0
xfeed_28193 1 0 decap_w0
xfeed_28192 1 0 decap_w0
xfeed_28191 1 0 decap_w0
xfeed_28190 1 0 decap_w0
xfeed_27669 1 0 decap_w0
xfeed_27668 1 0 decap_w0
xfeed_27667 1 0 decap_w0
xfeed_27666 1 0 decap_w0
xfeed_27665 1 0 decap_w0
xfeed_27664 1 0 decap_w0
xfeed_27663 1 0 decap_w0
xfeed_27662 1 0 decap_w0
xfeed_27661 1 0 decap_w0
xfeed_27660 1 0 decap_w0
xfeed_23359 1 0 decap_w0
xfeed_23358 1 0 decap_w0
xfeed_23357 1 0 decap_w0
xfeed_23356 1 0 decap_w0
xfeed_23355 1 0 decap_w0
xfeed_23354 1 0 decap_w0
xfeed_23353 1 0 decap_w0
xfeed_23352 1 0 decap_w0
xfeed_23351 1 0 decap_w0
xfeed_23350 1 0 decap_w0
xfeed_22829 1 0 decap_w0
xfeed_22828 1 0 decap_w0
xfeed_22827 1 0 decap_w0
xfeed_22826 1 0 decap_w0
xfeed_22825 1 0 decap_w0
xfeed_22824 1 0 decap_w0
xfeed_22823 1 0 decap_w0
xfeed_22822 1 0 decap_w0
xfeed_22821 1 0 decap_w0
xfeed_22820 1 0 decap_w0
xfeed_17359 1 0 decap_w0
xfeed_17358 1 0 decap_w0
xfeed_17357 1 0 decap_w0
xfeed_17356 1 0 decap_w0
xfeed_17355 1 0 decap_w0
xfeed_17354 1 0 decap_w0
xfeed_17353 1 0 decap_w0
xfeed_17352 1 0 decap_w0
xfeed_17351 1 0 decap_w0
xfeed_17350 1 0 decap_w0
xfeed_16829 1 0 decap_w0
xfeed_16828 1 0 decap_w0
xfeed_16827 1 0 decap_w0
xfeed_16826 1 0 decap_w0
xfeed_16825 1 0 decap_w0
xfeed_16824 1 0 decap_w0
xfeed_16823 1 0 decap_w0
xfeed_16822 1 0 decap_w0
xfeed_16821 1 0 decap_w0
xfeed_16820 1 0 decap_w0
xfeed_13049 1 0 decap_w0
xfeed_13048 1 0 decap_w0
xfeed_13047 1 0 decap_w0
xfeed_13046 1 0 decap_w0
xfeed_13045 1 0 decap_w0
xfeed_13044 1 0 decap_w0
xfeed_13043 1 0 decap_w0
xfeed_13042 1 0 decap_w0
xfeed_13041 1 0 decap_w0
xfeed_13040 1 0 decap_w0
xfeed_12519 1 0 decap_w0
xfeed_12518 1 0 decap_w0
xfeed_12517 1 0 decap_w0
xfeed_12516 1 0 decap_w0
xfeed_12515 1 0 decap_w0
xfeed_12514 1 0 decap_w0
xfeed_12513 1 0 decap_w0
xfeed_12512 1 0 decap_w0
xfeed_12511 1 0 decap_w0
xfeed_12510 1 0 decap_w0
xfeed_6319 1 0 decap_w0
xfeed_6318 1 0 decap_w0
xfeed_6317 1 0 decap_w0
xfeed_6316 1 0 decap_w0
xfeed_6315 1 0 decap_w0
xfeed_6314 1 0 decap_w0
xfeed_6313 1 0 decap_w0
xfeed_6312 1 0 decap_w0
xfeed_6311 1 0 decap_w0
xfeed_6310 1 0 decap_w0
xfeed_1390 1 0 decap_w0
xfeed_1391 1 0 decap_w0
xfeed_1392 1 0 decap_w0
xfeed_1393 1 0 decap_w0
xfeed_1394 1 0 decap_w0
xfeed_1395 1 0 decap_w0
xfeed_1396 1 0 decap_w0
xfeed_1397 1 0 decap_w0
xfeed_1398 1 0 decap_w0
xfeed_1399 1 0 decap_w0
xfeed_2000 1 0 decap_w0
xfeed_2001 1 0 decap_w0
xfeed_2002 1 0 decap_w0
xfeed_2003 1 0 decap_w0
xfeed_2004 1 0 decap_w0
xfeed_2005 1 0 decap_w0
xfeed_2006 1 0 decap_w0
xfeed_2007 1 0 decap_w0
xfeed_2008 1 0 decap_w0
xfeed_2009 1 0 decap_w0
xfeed_27679 1 0 decap_w0
xfeed_27678 1 0 decap_w0
xfeed_27677 1 0 decap_w0
xfeed_27676 1 0 decap_w0
xfeed_27675 1 0 decap_w0
xfeed_27674 1 0 decap_w0
xfeed_27673 1 0 decap_w0
xfeed_27672 1 0 decap_w0
xfeed_27671 1 0 decap_w0
xfeed_27670 1 0 decap_w0
xfeed_23369 1 0 decap_w0
xfeed_23368 1 0 decap_w0
xfeed_23367 1 0 decap_w0
xfeed_23366 1 0 decap_w0
xfeed_23365 1 0 decap_w0
xfeed_23364 1 0 decap_w0
xfeed_23363 1 0 decap_w0
xfeed_23362 1 0 decap_w0
xfeed_23361 1 0 decap_w0
xfeed_23360 1 0 decap_w0
xfeed_22839 1 0 decap_w0
xfeed_22838 1 0 decap_w0
xfeed_22837 1 0 decap_w0
xfeed_22836 1 0 decap_w0
xfeed_22835 1 0 decap_w0
xfeed_22834 1 0 decap_w0
xfeed_22833 1 0 decap_w0
xfeed_22832 1 0 decap_w0
xfeed_22831 1 0 decap_w0
xfeed_22830 1 0 decap_w0
xfeed_17369 1 0 decap_w0
xfeed_17368 1 0 decap_w0
xfeed_17367 1 0 decap_w0
xfeed_17366 1 0 decap_w0
xfeed_17365 1 0 decap_w0
xfeed_17364 1 0 decap_w0
xfeed_17363 1 0 decap_w0
xfeed_17362 1 0 decap_w0
xfeed_17361 1 0 decap_w0
xfeed_17360 1 0 decap_w0
xfeed_16839 1 0 decap_w0
xfeed_16838 1 0 decap_w0
xfeed_16837 1 0 decap_w0
xfeed_16836 1 0 decap_w0
xfeed_16835 1 0 decap_w0
xfeed_16834 1 0 decap_w0
xfeed_16833 1 0 decap_w0
xfeed_16832 1 0 decap_w0
xfeed_16831 1 0 decap_w0
xfeed_16830 1 0 decap_w0
xfeed_13059 1 0 decap_w0
xfeed_13058 1 0 decap_w0
xfeed_13057 1 0 decap_w0
xfeed_13056 1 0 decap_w0
xfeed_13055 1 0 decap_w0
xfeed_13054 1 0 decap_w0
xfeed_13053 1 0 decap_w0
xfeed_13052 1 0 decap_w0
xfeed_13051 1 0 decap_w0
xfeed_13050 1 0 decap_w0
xfeed_12529 1 0 decap_w0
xfeed_12528 1 0 decap_w0
xfeed_12527 1 0 decap_w0
xfeed_12526 1 0 decap_w0
xfeed_12525 1 0 decap_w0
xfeed_12524 1 0 decap_w0
xfeed_12523 1 0 decap_w0
xfeed_12522 1 0 decap_w0
xfeed_12521 1 0 decap_w0
xfeed_12520 1 0 decap_w0
xfeed_6329 1 0 decap_w0
xfeed_6328 1 0 decap_w0
xfeed_6327 1 0 decap_w0
xfeed_6326 1 0 decap_w0
xfeed_6325 1 0 decap_w0
xfeed_6324 1 0 decap_w0
xfeed_6323 1 0 decap_w0
xfeed_6322 1 0 decap_w0
xfeed_6321 1 0 decap_w0
xfeed_6320 1 0 decap_w0
xfeed_2010 1 0 decap_w0
xfeed_2011 1 0 decap_w0
xfeed_2012 1 0 decap_w0
xfeed_2013 1 0 decap_w0
xfeed_2014 1 0 decap_w0
xfeed_2015 1 0 decap_w0
xfeed_2016 1 0 decap_w0
xfeed_2017 1 0 decap_w0
xfeed_2018 1 0 decap_w0
xfeed_2019 1 0 decap_w0
xfeed_27689 1 0 decap_w0
xfeed_27688 1 0 decap_w0
xfeed_27687 1 0 decap_w0
xfeed_27686 1 0 decap_w0
xfeed_27685 1 0 decap_w0
xfeed_27684 1 0 decap_w0
xfeed_27683 1 0 decap_w0
xfeed_27682 1 0 decap_w0
xfeed_27681 1 0 decap_w0
xfeed_27680 1 0 decap_w0
xfeed_23379 1 0 decap_w0
xfeed_23378 1 0 decap_w0
xfeed_23377 1 0 decap_w0
xfeed_23376 1 0 decap_w0
xfeed_23375 1 0 decap_w0
xfeed_23374 1 0 decap_w0
xfeed_23373 1 0 decap_w0
xfeed_23372 1 0 decap_w0
xfeed_23371 1 0 decap_w0
xfeed_23370 1 0 decap_w0
xfeed_22849 1 0 decap_w0
xfeed_22848 1 0 decap_w0
xfeed_22847 1 0 decap_w0
xfeed_22846 1 0 decap_w0
xfeed_22845 1 0 decap_w0
xfeed_22844 1 0 decap_w0
xfeed_22843 1 0 decap_w0
xfeed_22842 1 0 decap_w0
xfeed_22841 1 0 decap_w0
xfeed_22840 1 0 decap_w0
xfeed_17379 1 0 decap_w0
xfeed_17378 1 0 decap_w0
xfeed_17377 1 0 decap_w0
xfeed_17376 1 0 decap_w0
xfeed_17375 1 0 decap_w0
xfeed_17374 1 0 decap_w0
xfeed_17373 1 0 decap_w0
xfeed_17372 1 0 decap_w0
xfeed_17371 1 0 decap_w0
xfeed_17370 1 0 decap_w0
xfeed_16849 1 0 decap_w0
xfeed_16848 1 0 decap_w0
xfeed_16847 1 0 decap_w0
xfeed_16846 1 0 decap_w0
xfeed_16845 1 0 decap_w0
xfeed_16844 1 0 decap_w0
xfeed_16843 1 0 decap_w0
xfeed_16842 1 0 decap_w0
xfeed_16841 1 0 decap_w0
xfeed_16840 1 0 decap_w0
xfeed_13069 1 0 decap_w0
xfeed_13068 1 0 decap_w0
xfeed_13067 1 0 decap_w0
xfeed_13066 1 0 decap_w0
xfeed_13065 1 0 decap_w0
xfeed_13064 1 0 decap_w0
xfeed_13063 1 0 decap_w0
xfeed_13062 1 0 decap_w0
xfeed_13061 1 0 decap_w0
xfeed_13060 1 0 decap_w0
xfeed_12539 1 0 decap_w0
xfeed_12538 1 0 decap_w0
xfeed_12537 1 0 decap_w0
xfeed_12536 1 0 decap_w0
xfeed_12535 1 0 decap_w0
xfeed_12534 1 0 decap_w0
xfeed_12533 1 0 decap_w0
xfeed_12532 1 0 decap_w0
xfeed_12531 1 0 decap_w0
xfeed_12530 1 0 decap_w0
xfeed_6339 1 0 decap_w0
xfeed_6338 1 0 decap_w0
xfeed_6337 1 0 decap_w0
xfeed_6336 1 0 decap_w0
xfeed_6335 1 0 decap_w0
xfeed_6334 1 0 decap_w0
xfeed_6333 1 0 decap_w0
xfeed_6332 1 0 decap_w0
xfeed_6331 1 0 decap_w0
xfeed_6330 1 0 decap_w0
xfeed_5809 1 0 decap_w0
xfeed_5808 1 0 decap_w0
xfeed_5807 1 0 decap_w0
xfeed_5806 1 0 decap_w0
xfeed_5805 1 0 decap_w0
xfeed_5804 1 0 decap_w0
xfeed_5803 1 0 decap_w0
xfeed_5802 1 0 decap_w0
xfeed_5801 1 0 decap_w0
xfeed_5800 1 0 decap_w0
xsubckt_0_nexor2_x0 1 0 64 34 138 nexor2_x0
xfeed_2020 1 0 decap_w0
xfeed_2021 1 0 decap_w0
xfeed_2022 1 0 decap_w0
xfeed_2023 1 0 decap_w0
xfeed_2024 1 0 decap_w0
xfeed_2025 1 0 decap_w0
xfeed_2026 1 0 decap_w0
xfeed_2027 1 0 decap_w0
xfeed_2028 1 0 decap_w0
xfeed_2029 1 0 decap_w0
xfeed_28309 1 0 decap_w0
xfeed_28308 1 0 decap_w0
xfeed_28307 1 0 decap_w0
xfeed_28306 1 0 decap_w0
xfeed_28305 1 0 decap_w0
xfeed_28304 1 0 decap_w0
xfeed_28303 1 0 decap_w0
xfeed_28302 1 0 decap_w0
xfeed_28301 1 0 decap_w0
xfeed_28300 1 0 decap_w0
xfeed_27699 1 0 decap_w0
xfeed_27698 1 0 decap_w0
xfeed_27697 1 0 decap_w0
xfeed_27696 1 0 decap_w0
xfeed_27695 1 0 decap_w0
xfeed_27694 1 0 decap_w0
xfeed_27693 1 0 decap_w0
xfeed_27692 1 0 decap_w0
xfeed_27691 1 0 decap_w0
xfeed_27690 1 0 decap_w0
xfeed_23389 1 0 decap_w0
xfeed_23388 1 0 decap_w0
xfeed_23387 1 0 decap_w0
xfeed_23386 1 0 decap_w0
xfeed_23385 1 0 decap_w0
xfeed_23384 1 0 decap_w0
xfeed_23383 1 0 decap_w0
xfeed_23382 1 0 decap_w0
xfeed_23381 1 0 decap_w0
xfeed_23380 1 0 decap_w0
xfeed_22859 1 0 decap_w0
xfeed_22858 1 0 decap_w0
xfeed_22857 1 0 decap_w0
xfeed_22856 1 0 decap_w0
xfeed_22855 1 0 decap_w0
xfeed_22854 1 0 decap_w0
xfeed_22853 1 0 decap_w0
xfeed_22852 1 0 decap_w0
xfeed_22851 1 0 decap_w0
xfeed_22850 1 0 decap_w0
xfeed_17389 1 0 decap_w0
xfeed_17388 1 0 decap_w0
xfeed_17387 1 0 decap_w0
xfeed_17386 1 0 decap_w0
xfeed_17385 1 0 decap_w0
xfeed_17384 1 0 decap_w0
xfeed_17383 1 0 decap_w0
xfeed_17382 1 0 decap_w0
xfeed_17381 1 0 decap_w0
xfeed_17380 1 0 decap_w0
xfeed_16856 1 0 decap_w0
xfeed_16855 1 0 decap_w0
xfeed_16854 1 0 decap_w0
xfeed_16853 1 0 decap_w0
xfeed_16852 1 0 decap_w0
xfeed_16851 1 0 decap_w0
xfeed_16850 1 0 decap_w0
xfeed_13079 1 0 decap_w0
xfeed_13078 1 0 decap_w0
xfeed_13077 1 0 decap_w0
xfeed_13076 1 0 decap_w0
xfeed_13075 1 0 decap_w0
xfeed_13074 1 0 decap_w0
xfeed_13073 1 0 decap_w0
xfeed_13072 1 0 decap_w0
xfeed_13071 1 0 decap_w0
xfeed_13070 1 0 decap_w0
xfeed_12549 1 0 decap_w0
xfeed_12548 1 0 decap_w0
xfeed_12547 1 0 decap_w0
xfeed_12546 1 0 decap_w0
xfeed_12545 1 0 decap_w0
xfeed_12544 1 0 decap_w0
xfeed_12543 1 0 decap_w0
xfeed_12542 1 0 decap_w0
xfeed_12541 1 0 decap_w0
xfeed_12540 1 0 decap_w0
xfeed_30009 1 0 decap_w0
xfeed_30008 1 0 decap_w0
xfeed_30007 1 0 decap_w0
xfeed_30006 1 0 decap_w0
xfeed_30005 1 0 decap_w0
xfeed_30004 1 0 decap_w0
xfeed_30003 1 0 decap_w0
xfeed_30002 1 0 decap_w0
xfeed_30001 1 0 decap_w0
xfeed_30000 1 0 decap_w0
xfeed_24002 1 0 decap_w0
xfeed_24001 1 0 decap_w0
xfeed_24000 1 0 decap_w0
xfeed_16859 1 0 decap_w0
xfeed_16858 1 0 decap_w0
xfeed_16857 1 0 decap_w0
xfeed_6349 1 0 decap_w0
xfeed_6348 1 0 decap_w0
xfeed_6347 1 0 decap_w0
xfeed_6346 1 0 decap_w0
xfeed_6345 1 0 decap_w0
xfeed_6344 1 0 decap_w0
xfeed_6343 1 0 decap_w0
xfeed_6342 1 0 decap_w0
xfeed_6341 1 0 decap_w0
xfeed_6340 1 0 decap_w0
xfeed_5819 1 0 decap_w0
xfeed_5818 1 0 decap_w0
xfeed_5817 1 0 decap_w0
xfeed_5816 1 0 decap_w0
xfeed_5815 1 0 decap_w0
xfeed_5814 1 0 decap_w0
xfeed_5813 1 0 decap_w0
xfeed_5812 1 0 decap_w0
xfeed_5811 1 0 decap_w0
xfeed_5810 1 0 decap_w0
xsubckt_12_nexor2_x0 1 0 132 137 131 nexor2_x0
xfeed_1500 1 0 decap_w0
xfeed_1501 1 0 decap_w0
xfeed_1502 1 0 decap_w0
xfeed_1503 1 0 decap_w0
xfeed_1504 1 0 decap_w0
xfeed_1505 1 0 decap_w0
xfeed_1506 1 0 decap_w0
xfeed_1507 1 0 decap_w0
xfeed_1508 1 0 decap_w0
xfeed_1509 1 0 decap_w0
xfeed_2030 1 0 decap_w0
xfeed_2031 1 0 decap_w0
xfeed_2032 1 0 decap_w0
xfeed_2033 1 0 decap_w0
xfeed_2034 1 0 decap_w0
xfeed_2035 1 0 decap_w0
xfeed_2036 1 0 decap_w0
xfeed_2037 1 0 decap_w0
xfeed_2038 1 0 decap_w0
xfeed_2039 1 0 decap_w0
xfeed_28319 1 0 decap_w0
xfeed_28318 1 0 decap_w0
xfeed_28317 1 0 decap_w0
xfeed_28316 1 0 decap_w0
xfeed_28315 1 0 decap_w0
xfeed_28314 1 0 decap_w0
xfeed_28313 1 0 decap_w0
xfeed_28312 1 0 decap_w0
xfeed_28311 1 0 decap_w0
xfeed_28310 1 0 decap_w0
xfeed_24009 1 0 decap_w0
xfeed_24008 1 0 decap_w0
xfeed_24007 1 0 decap_w0
xfeed_24006 1 0 decap_w0
xfeed_24005 1 0 decap_w0
xfeed_24004 1 0 decap_w0
xfeed_24003 1 0 decap_w0
xfeed_23399 1 0 decap_w0
xfeed_23398 1 0 decap_w0
xfeed_23397 1 0 decap_w0
xfeed_23396 1 0 decap_w0
xfeed_23395 1 0 decap_w0
xfeed_23394 1 0 decap_w0
xfeed_23393 1 0 decap_w0
xfeed_23392 1 0 decap_w0
xfeed_23391 1 0 decap_w0
xfeed_23390 1 0 decap_w0
xfeed_22869 1 0 decap_w0
xfeed_22868 1 0 decap_w0
xfeed_22867 1 0 decap_w0
xfeed_22866 1 0 decap_w0
xfeed_22865 1 0 decap_w0
xfeed_22864 1 0 decap_w0
xfeed_22863 1 0 decap_w0
xfeed_22862 1 0 decap_w0
xfeed_22861 1 0 decap_w0
xfeed_22860 1 0 decap_w0
xfeed_18009 1 0 decap_w0
xfeed_18008 1 0 decap_w0
xfeed_18007 1 0 decap_w0
xfeed_18006 1 0 decap_w0
xfeed_18005 1 0 decap_w0
xfeed_18004 1 0 decap_w0
xfeed_18003 1 0 decap_w0
xfeed_18002 1 0 decap_w0
xfeed_18001 1 0 decap_w0
xfeed_18000 1 0 decap_w0
xfeed_17399 1 0 decap_w0
xfeed_17398 1 0 decap_w0
xfeed_17397 1 0 decap_w0
xfeed_17396 1 0 decap_w0
xfeed_17395 1 0 decap_w0
xfeed_17394 1 0 decap_w0
xfeed_17393 1 0 decap_w0
xfeed_17392 1 0 decap_w0
xfeed_17391 1 0 decap_w0
xfeed_17390 1 0 decap_w0
xfeed_16863 1 0 decap_w0
xfeed_16862 1 0 decap_w0
xfeed_16861 1 0 decap_w0
xfeed_16860 1 0 decap_w0
xfeed_13089 1 0 decap_w0
xfeed_13088 1 0 decap_w0
xfeed_13087 1 0 decap_w0
xfeed_13086 1 0 decap_w0
xfeed_13085 1 0 decap_w0
xfeed_13084 1 0 decap_w0
xfeed_13083 1 0 decap_w0
xfeed_13082 1 0 decap_w0
xfeed_13081 1 0 decap_w0
xfeed_13080 1 0 decap_w0
xfeed_12559 1 0 decap_w0
xfeed_12558 1 0 decap_w0
xfeed_12557 1 0 decap_w0
xfeed_12556 1 0 decap_w0
xfeed_12555 1 0 decap_w0
xfeed_12554 1 0 decap_w0
xfeed_12553 1 0 decap_w0
xfeed_12552 1 0 decap_w0
xfeed_12551 1 0 decap_w0
xfeed_12550 1 0 decap_w0
xfeed_30019 1 0 decap_w0
xfeed_30018 1 0 decap_w0
xfeed_30017 1 0 decap_w0
xfeed_30016 1 0 decap_w0
xfeed_30015 1 0 decap_w0
xfeed_30014 1 0 decap_w0
xfeed_30013 1 0 decap_w0
xfeed_30012 1 0 decap_w0
xfeed_30011 1 0 decap_w0
xfeed_30010 1 0 decap_w0
xfeed_16869 1 0 decap_w0
xfeed_16868 1 0 decap_w0
xfeed_16867 1 0 decap_w0
xfeed_16866 1 0 decap_w0
xfeed_16865 1 0 decap_w0
xfeed_16864 1 0 decap_w0
xfeed_6359 1 0 decap_w0
xfeed_6358 1 0 decap_w0
xfeed_6357 1 0 decap_w0
xfeed_6356 1 0 decap_w0
xfeed_6355 1 0 decap_w0
xfeed_6354 1 0 decap_w0
xfeed_6353 1 0 decap_w0
xfeed_6352 1 0 decap_w0
xfeed_6351 1 0 decap_w0
xfeed_6350 1 0 decap_w0
xfeed_5829 1 0 decap_w0
xfeed_5828 1 0 decap_w0
xfeed_5827 1 0 decap_w0
xfeed_5826 1 0 decap_w0
xfeed_5825 1 0 decap_w0
xfeed_5824 1 0 decap_w0
xfeed_5823 1 0 decap_w0
xfeed_5822 1 0 decap_w0
xfeed_5821 1 0 decap_w0
xfeed_5820 1 0 decap_w0
xsubckt_90_nexor2_x0 1 0 147 149 146 nexor2_x0
xfeed_1510 1 0 decap_w0
xfeed_1511 1 0 decap_w0
xfeed_1512 1 0 decap_w0
xfeed_1513 1 0 decap_w0
xfeed_1514 1 0 decap_w0
xfeed_1515 1 0 decap_w0
xfeed_1516 1 0 decap_w0
xfeed_1517 1 0 decap_w0
xfeed_1518 1 0 decap_w0
xfeed_1519 1 0 decap_w0
xfeed_2040 1 0 decap_w0
xfeed_2041 1 0 decap_w0
xfeed_2042 1 0 decap_w0
xfeed_2043 1 0 decap_w0
xfeed_2044 1 0 decap_w0
xfeed_2045 1 0 decap_w0
xfeed_2046 1 0 decap_w0
xfeed_2047 1 0 decap_w0
xfeed_2048 1 0 decap_w0
xfeed_2049 1 0 decap_w0
xfeed_28329 1 0 decap_w0
xfeed_28328 1 0 decap_w0
xfeed_28327 1 0 decap_w0
xfeed_28326 1 0 decap_w0
xfeed_28325 1 0 decap_w0
xfeed_28324 1 0 decap_w0
xfeed_28323 1 0 decap_w0
xfeed_28322 1 0 decap_w0
xfeed_28321 1 0 decap_w0
xfeed_28320 1 0 decap_w0
xfeed_24019 1 0 decap_w0
xfeed_24018 1 0 decap_w0
xfeed_24017 1 0 decap_w0
xfeed_24016 1 0 decap_w0
xfeed_24015 1 0 decap_w0
xfeed_24014 1 0 decap_w0
xfeed_24013 1 0 decap_w0
xfeed_24012 1 0 decap_w0
xfeed_24011 1 0 decap_w0
xfeed_24010 1 0 decap_w0
xfeed_22879 1 0 decap_w0
xfeed_22878 1 0 decap_w0
xfeed_22877 1 0 decap_w0
xfeed_22876 1 0 decap_w0
xfeed_22875 1 0 decap_w0
xfeed_22874 1 0 decap_w0
xfeed_22873 1 0 decap_w0
xfeed_22872 1 0 decap_w0
xfeed_22871 1 0 decap_w0
xfeed_22870 1 0 decap_w0
xfeed_18019 1 0 decap_w0
xfeed_18018 1 0 decap_w0
xfeed_18017 1 0 decap_w0
xfeed_18016 1 0 decap_w0
xfeed_18015 1 0 decap_w0
xfeed_18014 1 0 decap_w0
xfeed_18013 1 0 decap_w0
xfeed_18012 1 0 decap_w0
xfeed_18011 1 0 decap_w0
xfeed_18010 1 0 decap_w0
xfeed_16870 1 0 decap_w0
xfeed_13099 1 0 decap_w0
xfeed_13098 1 0 decap_w0
xfeed_13097 1 0 decap_w0
xfeed_13096 1 0 decap_w0
xfeed_13095 1 0 decap_w0
xfeed_13094 1 0 decap_w0
xfeed_13093 1 0 decap_w0
xfeed_13092 1 0 decap_w0
xfeed_13091 1 0 decap_w0
xfeed_13090 1 0 decap_w0
xfeed_12569 1 0 decap_w0
xfeed_12568 1 0 decap_w0
xfeed_12567 1 0 decap_w0
xfeed_12566 1 0 decap_w0
xfeed_12565 1 0 decap_w0
xfeed_12564 1 0 decap_w0
xfeed_12563 1 0 decap_w0
xfeed_12562 1 0 decap_w0
xfeed_12561 1 0 decap_w0
xfeed_12560 1 0 decap_w0
xsubckt_81_nexor2_x0 1 0 154 159 153 nexor2_x0
xfeed_30029 1 0 decap_w0
xfeed_30028 1 0 decap_w0
xfeed_30027 1 0 decap_w0
xfeed_30026 1 0 decap_w0
xfeed_30025 1 0 decap_w0
xfeed_30024 1 0 decap_w0
xfeed_30023 1 0 decap_w0
xfeed_30022 1 0 decap_w0
xfeed_30021 1 0 decap_w0
xfeed_30020 1 0 decap_w0
xfeed_16879 1 0 decap_w0
xfeed_16878 1 0 decap_w0
xfeed_16877 1 0 decap_w0
xfeed_16876 1 0 decap_w0
xfeed_16875 1 0 decap_w0
xfeed_16874 1 0 decap_w0
xfeed_16873 1 0 decap_w0
xfeed_16872 1 0 decap_w0
xfeed_16871 1 0 decap_w0
xfeed_6369 1 0 decap_w0
xfeed_6368 1 0 decap_w0
xfeed_6367 1 0 decap_w0
xfeed_6366 1 0 decap_w0
xfeed_6365 1 0 decap_w0
xfeed_6364 1 0 decap_w0
xfeed_6363 1 0 decap_w0
xfeed_6362 1 0 decap_w0
xfeed_6361 1 0 decap_w0
xfeed_6360 1 0 decap_w0
xfeed_5839 1 0 decap_w0
xfeed_5838 1 0 decap_w0
xfeed_5837 1 0 decap_w0
xfeed_5836 1 0 decap_w0
xfeed_5835 1 0 decap_w0
xfeed_5834 1 0 decap_w0
xfeed_5833 1 0 decap_w0
xfeed_5832 1 0 decap_w0
xfeed_5831 1 0 decap_w0
xfeed_5830 1 0 decap_w0
xsubckt_72_nexor2_x0 1 0 161 25 24 nexor2_x0
xfeed_1520 1 0 decap_w0
xfeed_1521 1 0 decap_w0
xfeed_1522 1 0 decap_w0
xfeed_1523 1 0 decap_w0
xfeed_1524 1 0 decap_w0
xfeed_1525 1 0 decap_w0
xfeed_1526 1 0 decap_w0
xfeed_1527 1 0 decap_w0
xfeed_1528 1 0 decap_w0
xfeed_1529 1 0 decap_w0
xfeed_2050 1 0 decap_w0
xfeed_2051 1 0 decap_w0
xfeed_2052 1 0 decap_w0
xfeed_2053 1 0 decap_w0
xfeed_2054 1 0 decap_w0
xfeed_2055 1 0 decap_w0
xfeed_2056 1 0 decap_w0
xfeed_2057 1 0 decap_w0
xfeed_2058 1 0 decap_w0
xfeed_2059 1 0 decap_w0
xfeed_28339 1 0 decap_w0
xfeed_28338 1 0 decap_w0
xfeed_28337 1 0 decap_w0
xfeed_28336 1 0 decap_w0
xfeed_28335 1 0 decap_w0
xfeed_28334 1 0 decap_w0
xfeed_28333 1 0 decap_w0
xfeed_28332 1 0 decap_w0
xfeed_28331 1 0 decap_w0
xfeed_28330 1 0 decap_w0
xfeed_27809 1 0 decap_w0
xfeed_27808 1 0 decap_w0
xfeed_27807 1 0 decap_w0
xfeed_27806 1 0 decap_w0
xfeed_27805 1 0 decap_w0
xfeed_27804 1 0 decap_w0
xfeed_27803 1 0 decap_w0
xfeed_27802 1 0 decap_w0
xfeed_27801 1 0 decap_w0
xfeed_27800 1 0 decap_w0
xfeed_24029 1 0 decap_w0
xfeed_24028 1 0 decap_w0
xfeed_24027 1 0 decap_w0
xfeed_24026 1 0 decap_w0
xfeed_24025 1 0 decap_w0
xfeed_24024 1 0 decap_w0
xfeed_24023 1 0 decap_w0
xfeed_24022 1 0 decap_w0
xfeed_24021 1 0 decap_w0
xfeed_24020 1 0 decap_w0
xfeed_22889 1 0 decap_w0
xfeed_22888 1 0 decap_w0
xfeed_22887 1 0 decap_w0
xfeed_22886 1 0 decap_w0
xfeed_22885 1 0 decap_w0
xfeed_22884 1 0 decap_w0
xfeed_22883 1 0 decap_w0
xfeed_22882 1 0 decap_w0
xfeed_22881 1 0 decap_w0
xfeed_22880 1 0 decap_w0
xfeed_18029 1 0 decap_w0
xfeed_18028 1 0 decap_w0
xfeed_18027 1 0 decap_w0
xfeed_18026 1 0 decap_w0
xfeed_18025 1 0 decap_w0
xfeed_18024 1 0 decap_w0
xfeed_18023 1 0 decap_w0
xfeed_18022 1 0 decap_w0
xfeed_18021 1 0 decap_w0
xfeed_18020 1 0 decap_w0
xfeed_12577 1 0 decap_w0
xfeed_12576 1 0 decap_w0
xfeed_12575 1 0 decap_w0
xfeed_12574 1 0 decap_w0
xfeed_12573 1 0 decap_w0
xfeed_12572 1 0 decap_w0
xfeed_12571 1 0 decap_w0
xfeed_12570 1 0 decap_w0
xsubckt_63_nexor2_x0 1 0 168 173 166 nexor2_x0
xsubckt_54_nexor2_x0 1 0 63 33 173 nexor2_x0
xfeed_30039 1 0 decap_w0
xfeed_30038 1 0 decap_w0
xfeed_30037 1 0 decap_w0
xfeed_30036 1 0 decap_w0
xfeed_30035 1 0 decap_w0
xfeed_30034 1 0 decap_w0
xfeed_30033 1 0 decap_w0
xfeed_30032 1 0 decap_w0
xfeed_30031 1 0 decap_w0
xfeed_30030 1 0 decap_w0
xfeed_16889 1 0 decap_w0
xfeed_16888 1 0 tie
xfeed_16887 1 0 decap_w0
xfeed_16886 1 0 decap_w0
xfeed_16885 1 0 decap_w0
xfeed_16884 1 0 decap_w0
xfeed_16883 1 0 decap_w0
xfeed_16882 1 0 decap_w0
xfeed_16880 1 0 decap_w0
xfeed_12579 1 0 decap_w0
xfeed_12578 1 0 decap_w0
xfeed_6379 1 0 decap_w0
xfeed_6378 1 0 decap_w0
xfeed_6377 1 0 decap_w0
xfeed_6376 1 0 decap_w0
xfeed_6375 1 0 decap_w0
xfeed_6374 1 0 decap_w0
xfeed_6373 1 0 decap_w0
xfeed_6372 1 0 decap_w0
xfeed_6371 1 0 decap_w0
xfeed_6370 1 0 decap_w0
xfeed_5849 1 0 decap_w0
xfeed_5848 1 0 decap_w0
xfeed_5847 1 0 decap_w0
xfeed_5846 1 0 decap_w0
xfeed_5845 1 0 decap_w0
xfeed_5844 1 0 decap_w0
xfeed_5843 1 0 decap_w0
xfeed_5842 1 0 decap_w0
xfeed_5841 1 0 decap_w0
xfeed_5840 1 0 decap_w0
xsubckt_45_nexor2_x0 1 0 63 64 178 nexor2_x0
xfeed_1530 1 0 decap_w0
xfeed_1531 1 0 decap_w0
xfeed_1532 1 0 decap_w0
xfeed_1533 1 0 decap_w0
xfeed_1534 1 0 decap_w0
xfeed_1535 1 0 decap_w0
xfeed_1536 1 0 decap_w0
xfeed_1537 1 0 decap_w0
xfeed_1538 1 0 decap_w0
xfeed_1539 1 0 decap_w0
xfeed_2060 1 0 decap_w0
xfeed_2061 1 0 decap_w0
xfeed_2062 1 0 decap_w0
xfeed_2063 1 0 decap_w0
xfeed_2064 1 0 decap_w0
xfeed_2065 1 0 decap_w0
xfeed_2066 1 0 decap_w0
xfeed_2067 1 0 decap_w0
xfeed_2068 1 0 decap_w0
xfeed_2069 1 0 decap_w0
xfeed_28349 1 0 decap_w0
xfeed_28348 1 0 decap_w0
xfeed_28347 1 0 decap_w0
xfeed_28346 1 0 decap_w0
xfeed_28345 1 0 decap_w0
xfeed_28344 1 0 decap_w0
xfeed_28343 1 0 decap_w0
xfeed_28342 1 0 decap_w0
xfeed_28341 1 0 decap_w0
xfeed_28340 1 0 decap_w0
xfeed_27819 1 0 decap_w0
xfeed_27818 1 0 decap_w0
xfeed_27817 1 0 decap_w0
xfeed_27816 1 0 decap_w0
xfeed_27815 1 0 decap_w0
xfeed_27814 1 0 decap_w0
xfeed_27813 1 0 decap_w0
xfeed_27812 1 0 decap_w0
xfeed_27811 1 0 decap_w0
xfeed_27810 1 0 decap_w0
xfeed_24039 1 0 decap_w0
xfeed_24038 1 0 decap_w0
xfeed_24037 1 0 decap_w0
xfeed_24036 1 0 decap_w0
xfeed_24035 1 0 decap_w0
xfeed_24034 1 0 decap_w0
xfeed_24033 1 0 decap_w0
xfeed_24032 1 0 decap_w0
xfeed_24031 1 0 decap_w0
xfeed_24030 1 0 decap_w0
xfeed_23509 1 0 decap_w0
xfeed_23508 1 0 decap_w0
xfeed_23507 1 0 decap_w0
xfeed_23506 1 0 decap_w0
xfeed_23505 1 0 decap_w0
xfeed_23504 1 0 decap_w0
xfeed_23503 1 0 decap_w0
xfeed_23502 1 0 decap_w0
xfeed_23501 1 0 decap_w0
xfeed_23500 1 0 decap_w0
xfeed_22899 1 0 decap_w0
xfeed_22898 1 0 decap_w0
xfeed_22897 1 0 decap_w0
xfeed_22896 1 0 decap_w0
xfeed_22895 1 0 decap_w0
xfeed_22894 1 0 decap_w0
xfeed_22893 1 0 decap_w0
xfeed_22892 1 0 decap_w0
xfeed_22891 1 0 decap_w0
xfeed_22890 1 0 decap_w0
xfeed_18039 1 0 decap_w0
xfeed_18038 1 0 decap_w0
xfeed_18037 1 0 decap_w0
xfeed_18036 1 0 decap_w0
xfeed_18035 1 0 decap_w0
xfeed_18034 1 0 decap_w0
xfeed_18033 1 0 decap_w0
xfeed_18032 1 0 decap_w0
xfeed_18031 1 0 decap_w0
xfeed_18030 1 0 decap_w0
xfeed_17509 1 0 decap_w0
xfeed_17508 1 0 decap_w0
xfeed_17507 1 0 decap_w0
xfeed_17506 1 0 decap_w0
xfeed_17505 1 0 decap_w0
xfeed_17504 1 0 decap_w0
xfeed_17503 1 0 decap_w0
xfeed_17502 1 0 decap_w0
xfeed_17501 1 0 decap_w0
xfeed_17500 1 0 decap_w0
xfeed_12584 1 0 decap_w0
xfeed_12583 1 0 decap_w0
xfeed_12582 1 0 decap_w0
xfeed_12581 1 0 decap_w0
xfeed_12580 1 0 decap_w0
xsubckt_36_nexor2_x0 1 0 115 20 18 nexor2_x0
xfeed_30049 1 0 decap_w0
xfeed_30048 1 0 decap_w0
xfeed_30047 1 0 decap_w0
xfeed_30046 1 0 decap_w0
xfeed_30045 1 0 decap_w0
xfeed_30044 1 0 decap_w0
xfeed_30043 1 0 decap_w0
xfeed_30042 1 0 decap_w0
xfeed_30041 1 0 decap_w0
xfeed_30040 1 0 decap_w0
xfeed_16899 1 0 decap_w0
xfeed_16898 1 0 decap_w0
xfeed_16897 1 0 decap_w0
xfeed_16896 1 0 decap_w0
xfeed_16895 1 0 decap_w0
xfeed_16894 1 0 decap_w0
xfeed_16893 1 0 decap_w0
xfeed_16892 1 0 decap_w0
xfeed_16891 1 0 decap_w0
xfeed_16890 1 0 decap_w0
xfeed_12589 1 0 decap_w0
xfeed_12588 1 0 decap_w0
xfeed_12587 1 0 decap_w0
xfeed_12586 1 0 decap_w0
xfeed_12585 1 0 decap_w0
xfeed_6389 1 0 decap_w0
xfeed_6388 1 0 decap_w0
xfeed_6387 1 0 decap_w0
xfeed_6386 1 0 decap_w0
xfeed_6385 1 0 decap_w0
xfeed_6384 1 0 decap_w0
xfeed_6383 1 0 decap_w0
xfeed_6382 1 0 decap_w0
xfeed_6381 1 0 decap_w0
xfeed_6380 1 0 decap_w0
xfeed_5859 1 0 decap_w0
xfeed_5858 1 0 decap_w0
xfeed_5857 1 0 decap_w0
xfeed_5856 1 0 decap_w0
xfeed_5855 1 0 decap_w0
xfeed_5854 1 0 decap_w0
xfeed_5853 1 0 decap_w0
xfeed_5852 1 0 decap_w0
xfeed_5851 1 0 decap_w0
xfeed_5850 1 0 decap_w0
xfeed_1540 1 0 decap_w0
xfeed_1541 1 0 decap_w0
xfeed_1542 1 0 decap_w0
xfeed_1543 1 0 decap_w0
xfeed_1544 1 0 decap_w0
xfeed_1545 1 0 decap_w0
xfeed_1546 1 0 decap_w0
xfeed_1547 1 0 decap_w0
xfeed_1548 1 0 decap_w0
xfeed_1549 1 0 decap_w0
xfeed_2070 1 0 decap_w0
xfeed_2071 1 0 decap_w0
xfeed_2072 1 0 decap_w0
xfeed_2073 1 0 decap_w0
xfeed_2074 1 0 decap_w0
xfeed_2075 1 0 decap_w0
xfeed_2076 1 0 decap_w0
xfeed_2077 1 0 decap_w0
xfeed_2078 1 0 decap_w0
xfeed_2079 1 0 decap_w0
xdiode_19 1 0 3 diode_w1
xdiode_18 1 0 59 diode_w1
xdiode_17 1 0 59 diode_w1
xdiode_16 1 0 36 diode_w1
xdiode_15 1 0 36 diode_w1
xdiode_14 1 0 36 diode_w1
xdiode_13 1 0 37 diode_w1
xdiode_12 1 0 37 diode_w1
xdiode_11 1 0 38 diode_w1
xdiode_10 1 0 38 diode_w1
xfeed_28359 1 0 decap_w0
xfeed_28358 1 0 decap_w0
xfeed_28357 1 0 decap_w0
xfeed_28356 1 0 decap_w0
xfeed_28355 1 0 decap_w0
xfeed_28354 1 0 decap_w0
xfeed_28353 1 0 decap_w0
xfeed_28352 1 0 decap_w0
xfeed_28351 1 0 decap_w0
xfeed_28350 1 0 decap_w0
xfeed_27829 1 0 decap_w0
xfeed_27828 1 0 decap_w0
xfeed_27827 1 0 decap_w0
xfeed_27826 1 0 decap_w0
xfeed_27825 1 0 decap_w0
xfeed_27824 1 0 decap_w0
xfeed_27823 1 0 decap_w0
xfeed_27822 1 0 decap_w0
xfeed_27821 1 0 decap_w0
xfeed_27820 1 0 decap_w0
xfeed_24049 1 0 decap_w0
xfeed_24048 1 0 decap_w0
xfeed_24047 1 0 decap_w0
xfeed_24046 1 0 decap_w0
xfeed_24045 1 0 decap_w0
xfeed_24044 1 0 decap_w0
xfeed_24043 1 0 decap_w0
xfeed_24042 1 0 decap_w0
xfeed_24041 1 0 decap_w0
xfeed_24040 1 0 decap_w0
xfeed_23519 1 0 decap_w0
xfeed_23518 1 0 decap_w0
xfeed_23517 1 0 decap_w0
xfeed_23516 1 0 decap_w0
xfeed_23515 1 0 decap_w0
xfeed_23514 1 0 decap_w0
xfeed_23513 1 0 decap_w0
xfeed_23512 1 0 decap_w0
xfeed_23511 1 0 decap_w0
xfeed_23510 1 0 decap_w0
xfeed_18049 1 0 decap_w0
xfeed_18048 1 0 decap_w0
xfeed_18047 1 0 decap_w0
xfeed_18046 1 0 decap_w0
xfeed_18045 1 0 decap_w0
xfeed_18044 1 0 decap_w0
xfeed_18043 1 0 decap_w0
xfeed_18042 1 0 decap_w0
xfeed_18041 1 0 decap_w0
xfeed_18040 1 0 decap_w0
xfeed_17519 1 0 decap_w0
xfeed_17518 1 0 decap_w0
xfeed_17517 1 0 decap_w0
xfeed_17516 1 0 decap_w0
xfeed_17515 1 0 decap_w0
xfeed_17514 1 0 decap_w0
xfeed_17513 1 0 decap_w0
xfeed_17512 1 0 decap_w0
xfeed_17511 1 0 decap_w0
xfeed_17510 1 0 decap_w0
xfeed_13209 1 0 decap_w0
xfeed_13208 1 0 decap_w0
xfeed_13207 1 0 decap_w0
xfeed_13206 1 0 decap_w0
xfeed_13205 1 0 decap_w0
xfeed_13204 1 0 decap_w0
xfeed_13203 1 0 decap_w0
xfeed_13202 1 0 decap_w0
xfeed_13201 1 0 decap_w0
xfeed_13200 1 0 decap_w0
xfeed_12591 1 0 decap_w0
xfeed_12590 1 0 decap_w0
xfeed_30059 1 0 decap_w0
xfeed_30058 1 0 decap_w0
xfeed_30057 1 0 decap_w0
xfeed_30056 1 0 decap_w0
xfeed_30055 1 0 decap_w0
xfeed_30054 1 0 decap_w0
xfeed_30053 1 0 decap_w0
xfeed_30052 1 0 decap_w0
xfeed_30051 1 0 decap_w0
xfeed_30050 1 0 decap_w0
xfeed_12599 1 0 decap_w0
xfeed_12598 1 0 decap_w0
xfeed_12597 1 0 decap_w0
xfeed_12596 1 0 decap_w0
xfeed_12595 1 0 decap_w0
xfeed_12594 1 0 decap_w0
xfeed_12593 1 0 decap_w0
xfeed_12592 1 0 decap_w0
xfeed_7009 1 0 decap_w0
xfeed_7008 1 0 decap_w0
xfeed_7007 1 0 decap_w0
xfeed_7006 1 0 decap_w0
xfeed_7005 1 0 decap_w0
xfeed_7004 1 0 decap_w0
xfeed_7003 1 0 decap_w0
xfeed_7002 1 0 decap_w0
xfeed_7001 1 0 decap_w0
xfeed_7000 1 0 decap_w0
xfeed_6399 1 0 decap_w0
xfeed_6398 1 0 decap_w0
xfeed_6397 1 0 decap_w0
xfeed_6396 1 0 decap_w0
xfeed_6395 1 0 decap_w0
xfeed_6394 1 0 decap_w0
xfeed_6393 1 0 decap_w0
xfeed_6392 1 0 decap_w0
xfeed_6391 1 0 decap_w0
xfeed_6390 1 0 decap_w0
xfeed_5869 1 0 decap_w0
xfeed_5868 1 0 decap_w0
xfeed_5867 1 0 decap_w0
xfeed_5866 1 0 decap_w0
xfeed_5865 1 0 decap_w0
xfeed_5864 1 0 decap_w0
xfeed_5863 1 0 decap_w0
xfeed_5862 1 0 decap_w0
xfeed_5861 1 0 decap_w0
xfeed_5860 1 0 decap_w0
xfeed_1550 1 0 decap_w0
xfeed_1551 1 0 decap_w0
xfeed_1552 1 0 decap_w0
xfeed_1553 1 0 decap_w0
xfeed_1554 1 0 decap_w0
xfeed_1555 1 0 decap_w0
xfeed_1556 1 0 decap_w0
xfeed_1557 1 0 decap_w0
xfeed_1558 1 0 decap_w0
xfeed_1559 1 0 decap_w0
xfeed_2080 1 0 decap_w0
xfeed_2081 1 0 decap_w0
xfeed_2082 1 0 decap_w0
xfeed_2083 1 0 decap_w0
xfeed_2084 1 0 decap_w0
xfeed_2085 1 0 decap_w0
xfeed_2086 1 0 decap_w0
xfeed_2087 1 0 decap_w0
xfeed_2088 1 0 decap_w0
xfeed_2089 1 0 decap_w0
xdiode_21 1 0 3 diode_w1
xdiode_20 1 0 3 diode_w1
xfeed_28369 1 0 decap_w0
xfeed_28368 1 0 decap_w0
xfeed_28367 1 0 decap_w0
xfeed_28366 1 0 decap_w0
xfeed_28365 1 0 decap_w0
xfeed_28364 1 0 decap_w0
xfeed_28363 1 0 decap_w0
xfeed_28362 1 0 decap_w0
xfeed_28361 1 0 decap_w0
xfeed_28360 1 0 decap_w0
xfeed_27839 1 0 decap_w0
xfeed_27838 1 0 decap_w0
xfeed_27837 1 0 decap_w0
xfeed_27836 1 0 decap_w0
xfeed_27835 1 0 decap_w0
xfeed_27834 1 0 decap_w0
xfeed_27833 1 0 decap_w0
xfeed_27832 1 0 decap_w0
xfeed_27831 1 0 decap_w0
xfeed_27830 1 0 decap_w0
xfeed_24059 1 0 decap_w0
xfeed_24058 1 0 decap_w0
xfeed_24057 1 0 decap_w0
xfeed_24056 1 0 decap_w0
xfeed_24055 1 0 decap_w0
xfeed_24054 1 0 decap_w0
xfeed_24053 1 0 decap_w0
xfeed_24052 1 0 decap_w0
xfeed_24051 1 0 decap_w0
xfeed_24050 1 0 decap_w0
xfeed_23529 1 0 decap_w0
xfeed_23528 1 0 decap_w0
xfeed_23527 1 0 decap_w0
xfeed_23526 1 0 decap_w0
xfeed_23525 1 0 decap_w0
xfeed_23524 1 0 decap_w0
xfeed_23523 1 0 decap_w0
xfeed_23522 1 0 decap_w0
xfeed_23521 1 0 decap_w0
xfeed_23520 1 0 decap_w0
xfeed_18059 1 0 decap_w0
xfeed_18058 1 0 decap_w0
xfeed_18057 1 0 decap_w0
xfeed_18056 1 0 decap_w0
xfeed_18055 1 0 decap_w0
xfeed_18054 1 0 decap_w0
xfeed_18053 1 0 decap_w0
xfeed_18052 1 0 decap_w0
xfeed_18051 1 0 decap_w0
xfeed_18050 1 0 decap_w0
xfeed_17529 1 0 decap_w0
xfeed_17528 1 0 decap_w0
xfeed_17527 1 0 decap_w0
xfeed_17526 1 0 decap_w0
xfeed_17525 1 0 decap_w0
xfeed_17524 1 0 decap_w0
xfeed_17523 1 0 decap_w0
xfeed_17522 1 0 decap_w0
xfeed_17521 1 0 decap_w0
xfeed_17520 1 0 decap_w0
xfeed_13219 1 0 decap_w0
xfeed_13218 1 0 decap_w0
xfeed_13217 1 0 decap_w0
xfeed_13216 1 0 decap_w0
xfeed_13215 1 0 decap_w0
xfeed_13214 1 0 decap_w0
xfeed_13213 1 0 decap_w0
xfeed_13212 1 0 decap_w0
xfeed_13211 1 0 decap_w0
xfeed_13210 1 0 decap_w0
xsubckt_87_nexor2_x0 1 0 150 16 15 nexor2_x0
xfeed_30069 1 0 decap_w0
xfeed_30068 1 0 decap_w0
xfeed_30067 1 0 decap_w0
xfeed_30066 1 0 decap_w0
xfeed_30065 1 0 decap_w0
xfeed_30064 1 0 decap_w0
xfeed_30063 1 0 decap_w0
xfeed_30062 1 0 decap_w0
xfeed_30061 1 0 decap_w0
xfeed_30060 1 0 decap_w0
xfeed_7019 1 0 decap_w0
xfeed_7018 1 0 decap_w0
xfeed_7017 1 0 decap_w0
xfeed_7016 1 0 decap_w0
xfeed_7015 1 0 decap_w0
xfeed_7014 1 0 decap_w0
xfeed_7013 1 0 decap_w0
xfeed_7012 1 0 decap_w0
xfeed_7011 1 0 decap_w0
xfeed_7010 1 0 decap_w0
xfeed_5876 1 0 decap_w0
xfeed_5875 1 0 decap_w0
xfeed_5874 1 0 decap_w0
xfeed_5873 1 0 decap_w0
xfeed_5872 1 0 decap_w0
xfeed_5871 1 0 decap_w0
xfeed_5870 1 0 decap_w0
xspare_feed_109 1 0 tie
xspare_feed_108 1 0 decap_w0
xspare_feed_107 1 0 tie
xspare_feed_106 1 0 tie
xspare_feed_105 1 0 decap_w0
xspare_feed_104 1 0 tie
xspare_feed_103 1 0 tie
xspare_feed_102 1 0 decap_w0
xspare_feed_101 1 0 tie
xspare_feed_100 1 0 tie
xsubckt_78_nexor2_x0 1 0 157 161 155 nexor2_x0
xsubckt_69_nexor2_x0 1 0 162 119 26 nexor2_x0
xfeed_1560 1 0 decap_w0
xfeed_1561 1 0 decap_w0
xfeed_1562 1 0 decap_w0
xfeed_1563 1 0 decap_w0
xfeed_1564 1 0 decap_w0
xfeed_1565 1 0 decap_w0
xfeed_1566 1 0 decap_w0
xfeed_1567 1 0 decap_w0
xfeed_1568 1 0 decap_w0
xfeed_1569 1 0 decap_w0
xfeed_2090 1 0 decap_w0
xfeed_2091 1 0 decap_w0
xfeed_2092 1 0 decap_w0
xfeed_2093 1 0 decap_w0
xfeed_2094 1 0 decap_w0
xfeed_2095 1 0 decap_w0
xfeed_2096 1 0 decap_w0
xfeed_2097 1 0 decap_w0
xfeed_2098 1 0 decap_w0
xfeed_2099 1 0 decap_w0
xfeed_28379 1 0 decap_w0
xfeed_28378 1 0 decap_w0
xfeed_28377 1 0 decap_w0
xfeed_28376 1 0 decap_w0
xfeed_28375 1 0 decap_w0
xfeed_28374 1 0 decap_w0
xfeed_28373 1 0 decap_w0
xfeed_28372 1 0 decap_w0
xfeed_28371 1 0 decap_w0
xfeed_28370 1 0 decap_w0
xfeed_27849 1 0 decap_w0
xfeed_27848 1 0 decap_w0
xfeed_27847 1 0 decap_w0
xfeed_27846 1 0 decap_w0
xfeed_27845 1 0 decap_w0
xfeed_27844 1 0 decap_w0
xfeed_27843 1 0 decap_w0
xfeed_27842 1 0 decap_w0
xfeed_27841 1 0 decap_w0
xfeed_27840 1 0 decap_w0
xfeed_24069 1 0 decap_w0
xfeed_24068 1 0 decap_w0
xfeed_24067 1 0 decap_w0
xfeed_24066 1 0 decap_w0
xfeed_24065 1 0 decap_w0
xfeed_24064 1 0 decap_w0
xfeed_24063 1 0 decap_w0
xfeed_24062 1 0 decap_w0
xfeed_24061 1 0 decap_w0
xfeed_24060 1 0 decap_w0
xfeed_23539 1 0 decap_w0
xfeed_23538 1 0 decap_w0
xfeed_23537 1 0 decap_w0
xfeed_23536 1 0 decap_w0
xfeed_23535 1 0 decap_w0
xfeed_23534 1 0 decap_w0
xfeed_23533 1 0 decap_w0
xfeed_23532 1 0 decap_w0
xfeed_23531 1 0 decap_w0
xfeed_23530 1 0 decap_w0
xfeed_18069 1 0 decap_w0
xfeed_18068 1 0 decap_w0
xfeed_18067 1 0 decap_w0
xfeed_18066 1 0 decap_w0
xfeed_18065 1 0 decap_w0
xfeed_18064 1 0 decap_w0
xfeed_18063 1 0 decap_w0
xfeed_18062 1 0 decap_w0
xfeed_18061 1 0 decap_w0
xfeed_18060 1 0 decap_w0
xfeed_17539 1 0 decap_w0
xfeed_17538 1 0 decap_w0
xfeed_17537 1 0 decap_w0
xfeed_17536 1 0 decap_w0
xfeed_17535 1 0 decap_w0
xfeed_17534 1 0 decap_w0
xfeed_17533 1 0 decap_w0
xfeed_17532 1 0 decap_w0
xfeed_17531 1 0 decap_w0
xfeed_17530 1 0 decap_w0
xfeed_13229 1 0 decap_w0
xfeed_13228 1 0 decap_w0
xfeed_13227 1 0 decap_w0
xfeed_13226 1 0 decap_w0
xfeed_13225 1 0 decap_w0
xfeed_13224 1 0 decap_w0
xfeed_13223 1 0 decap_w0
xfeed_13222 1 0 decap_w0
xfeed_13221 1 0 decap_w0
xfeed_13220 1 0 decap_w0
xfeed_5879 1 0 decap_w0
xfeed_5878 1 0 decap_w0
xfeed_5877 1 0 decap_w0
xfeed_30078 1 0 decap_w0
xfeed_30077 1 0 decap_w0
xfeed_30076 1 0 decap_w0
xfeed_30075 1 0 decap_w0
xfeed_30074 1 0 decap_w0
xfeed_30073 1 0 decap_w0
xfeed_30072 1 0 decap_w0
xfeed_30071 1 0 decap_w0
xfeed_30070 1 0 decap_w0
xfeed_7029 1 0 decap_w0
xfeed_7028 1 0 decap_w0
xfeed_7027 1 0 decap_w0
xfeed_7026 1 0 decap_w0
xfeed_7025 1 0 decap_w0
xfeed_7024 1 0 decap_w0
xfeed_7023 1 0 decap_w0
xfeed_7022 1 0 decap_w0
xfeed_7021 1 0 decap_w0
xfeed_7020 1 0 decap_w0
xfeed_5883 1 0 decap_w0
xfeed_5882 1 0 decap_w0
xfeed_5881 1 0 decap_w0
xfeed_5880 1 0 decap_w0
xspare_feed_119 1 0 tie
xspare_feed_118 1 0 tie
xspare_feed_117 1 0 decap_w0
xspare_feed_116 1 0 tie
xspare_feed_115 1 0 tie
xspare_feed_114 1 0 decap_w0
xspare_feed_113 1 0 tie
xspare_feed_112 1 0 tie
xspare_feed_111 1 0 decap_w0
xspare_feed_110 1 0 tie
xsubckt_58_xor2_x0 1 0 41 61 170 xor2_x0
xfeed_1570 1 0 decap_w0
xfeed_1571 1 0 decap_w0
xfeed_1572 1 0 decap_w0
xfeed_1573 1 0 decap_w0
xfeed_1574 1 0 decap_w0
xfeed_1575 1 0 decap_w0
xfeed_1576 1 0 decap_w0
xfeed_1577 1 0 decap_w0
xfeed_1578 1 0 decap_w0
xfeed_1579 1 0 decap_w0
xfeed_30079 1 0 decap_w0
xfeed_28389 1 0 decap_w0
xfeed_28388 1 0 decap_w0
xfeed_28387 1 0 decap_w0
xfeed_28386 1 0 decap_w0
xfeed_28385 1 0 decap_w0
xfeed_28384 1 0 decap_w0
xfeed_28383 1 0 decap_w0
xfeed_28382 1 0 decap_w0
xfeed_28381 1 0 decap_w0
xfeed_28380 1 0 decap_w0
xfeed_27859 1 0 decap_w0
xfeed_27858 1 0 decap_w0
xfeed_27857 1 0 decap_w0
xfeed_27856 1 0 decap_w0
xfeed_27855 1 0 decap_w0
xfeed_27854 1 0 decap_w0
xfeed_27853 1 0 decap_w0
xfeed_27852 1 0 decap_w0
xfeed_27851 1 0 decap_w0
xfeed_27850 1 0 decap_w0
xfeed_24079 1 0 decap_w0
xfeed_24078 1 0 decap_w0
xfeed_24077 1 0 decap_w0
xfeed_24076 1 0 decap_w0
xfeed_24075 1 0 decap_w0
xfeed_24074 1 0 decap_w0
xfeed_24073 1 0 decap_w0
xfeed_24072 1 0 decap_w0
xfeed_24071 1 0 decap_w0
xfeed_24070 1 0 decap_w0
xfeed_23549 1 0 decap_w0
xfeed_23548 1 0 decap_w0
xfeed_23547 1 0 decap_w0
xfeed_23546 1 0 decap_w0
xfeed_23545 1 0 decap_w0
xfeed_23544 1 0 decap_w0
xfeed_23543 1 0 decap_w0
xfeed_23542 1 0 decap_w0
xfeed_23541 1 0 decap_w0
xfeed_23540 1 0 decap_w0
xfeed_18079 1 0 decap_w0
xfeed_18078 1 0 decap_w0
xfeed_18077 1 0 decap_w0
xfeed_18076 1 0 decap_w0
xfeed_18075 1 0 decap_w0
xfeed_18074 1 0 decap_w0
xfeed_18073 1 0 decap_w0
xfeed_18072 1 0 decap_w0
xfeed_18071 1 0 decap_w0
xfeed_18070 1 0 decap_w0
xfeed_17549 1 0 decap_w0
xfeed_17548 1 0 decap_w0
xfeed_17547 1 0 decap_w0
xfeed_17546 1 0 decap_w0
xfeed_17545 1 0 decap_w0
xfeed_17544 1 0 decap_w0
xfeed_17543 1 0 decap_w0
xfeed_17542 1 0 decap_w0
xfeed_17541 1 0 decap_w0
xfeed_17540 1 0 decap_w0
xfeed_13239 1 0 decap_w0
xfeed_13238 1 0 decap_w0
xfeed_13237 1 0 decap_w0
xfeed_13236 1 0 decap_w0
xfeed_13235 1 0 decap_w0
xfeed_13234 1 0 decap_w0
xfeed_13233 1 0 decap_w0
xfeed_13232 1 0 decap_w0
xfeed_13231 1 0 decap_w0
xfeed_13230 1 0 decap_w0
xfeed_12709 1 0 decap_w0
xfeed_12708 1 0 decap_w0
xfeed_12707 1 0 decap_w0
xfeed_12706 1 0 decap_w0
xfeed_12705 1 0 decap_w0
xfeed_12704 1 0 decap_w0
xfeed_12703 1 0 decap_w0
xfeed_12702 1 0 decap_w0
xfeed_12701 1 0 decap_w0
xfeed_12700 1 0 decap_w0
xfeed_5889 1 0 decap_w0
xfeed_5888 1 0 decap_w0
xfeed_5887 1 0 decap_w0
xfeed_5886 1 0 decap_w0
xfeed_5885 1 0 decap_w0
xfeed_5884 1 0 decap_w0
xfeed_30085 1 0 decap_w0
xfeed_30084 1 0 decap_w0
xfeed_30083 1 0 decap_w0
xfeed_30082 1 0 decap_w0
xfeed_30081 1 0 decap_w0
xfeed_30080 1 0 decap_w0
xfeed_7039 1 0 decap_w0
xfeed_7038 1 0 decap_w0
xfeed_7037 1 0 decap_w0
xfeed_7036 1 0 decap_w0
xfeed_7035 1 0 decap_w0
xfeed_7034 1 0 decap_w0
xfeed_7033 1 0 decap_w0
xfeed_7032 1 0 decap_w0
xfeed_7031 1 0 decap_w0
xfeed_7030 1 0 decap_w0
xfeed_6509 1 0 decap_w0
xfeed_6508 1 0 decap_w0
xfeed_6507 1 0 decap_w0
xfeed_6506 1 0 decap_w0
xfeed_6505 1 0 decap_w0
xfeed_6504 1 0 decap_w0
xfeed_6503 1 0 decap_w0
xfeed_6502 1 0 decap_w0
xfeed_6501 1 0 decap_w0
xfeed_6500 1 0 decap_w0
xfeed_5890 1 0 decap_w0
xspare_feed_129 1 0 decap_w0
xspare_feed_128 1 0 tie
xspare_feed_127 1 0 tie
xspare_feed_126 1 0 decap_w0
xspare_feed_125 1 0 tie
xspare_feed_124 1 0 tie
xspare_feed_123 1 0 decap_w0
xspare_feed_122 1 0 tie
xspare_feed_121 1 0 tie
xspare_feed_120 1 0 decap_w0
xfeed_1580 1 0 decap_w0
xfeed_1581 1 0 decap_w0
xfeed_1582 1 0 decap_w0
xfeed_1583 1 0 decap_w0
xfeed_1584 1 0 decap_w0
xfeed_1585 1 0 decap_w0
xfeed_1586 1 0 decap_w0
xfeed_1587 1 0 decap_w0
xfeed_1588 1 0 decap_w0
xfeed_1589 1 0 decap_w0
xfeed_30089 1 0 decap_w0
xfeed_30088 1 0 decap_w0
xfeed_30087 1 0 decap_w0
xfeed_30086 1 0 decap_w0
xfeed_29009 1 0 decap_w0
xfeed_29008 1 0 decap_w0
xfeed_29007 1 0 decap_w0
xfeed_29006 1 0 decap_w0
xfeed_29005 1 0 decap_w0
xfeed_29004 1 0 decap_w0
xfeed_29003 1 0 decap_w0
xfeed_29002 1 0 decap_w0
xfeed_29001 1 0 decap_w0
xfeed_29000 1 0 decap_w0
xfeed_28399 1 0 decap_w0
xfeed_28398 1 0 decap_w0
xfeed_28397 1 0 decap_w0
xfeed_28396 1 0 decap_w0
xfeed_28395 1 0 decap_w0
xfeed_28394 1 0 decap_w0
xfeed_28393 1 0 decap_w0
xfeed_28392 1 0 decap_w0
xfeed_28391 1 0 decap_w0
xfeed_28390 1 0 decap_w0
xfeed_27869 1 0 decap_w0
xfeed_27868 1 0 decap_w0
xfeed_27867 1 0 decap_w0
xfeed_27866 1 0 decap_w0
xfeed_27865 1 0 decap_w0
xfeed_27864 1 0 decap_w0
xfeed_27863 1 0 decap_w0
xfeed_27862 1 0 decap_w0
xfeed_27861 1 0 decap_w0
xfeed_27860 1 0 decap_w0
xfeed_24089 1 0 decap_w0
xfeed_24088 1 0 decap_w0
xfeed_24087 1 0 decap_w0
xfeed_24086 1 0 decap_w0
xfeed_24085 1 0 decap_w0
xfeed_24084 1 0 decap_w0
xfeed_24083 1 0 decap_w0
xfeed_24082 1 0 decap_w0
xfeed_24081 1 0 decap_w0
xfeed_24080 1 0 decap_w0
xfeed_23559 1 0 decap_w0
xfeed_23558 1 0 decap_w0
xfeed_23557 1 0 decap_w0
xfeed_23556 1 0 decap_w0
xfeed_23555 1 0 decap_w0
xfeed_23554 1 0 decap_w0
xfeed_23553 1 0 decap_w0
xfeed_23552 1 0 decap_w0
xfeed_23551 1 0 decap_w0
xfeed_23550 1 0 decap_w0
xfeed_18089 1 0 decap_w0
xfeed_18088 1 0 decap_w0
xfeed_18087 1 0 decap_w0
xfeed_18086 1 0 decap_w0
xfeed_18085 1 0 decap_w0
xfeed_18084 1 0 decap_w0
xfeed_18083 1 0 decap_w0
xfeed_18082 1 0 decap_w0
xfeed_18081 1 0 decap_w0
xfeed_18080 1 0 decap_w0
xfeed_17556 1 0 decap_w0
xfeed_17555 1 0 decap_w0
xfeed_17554 1 0 decap_w0
xfeed_17553 1 0 decap_w0
xfeed_17552 1 0 decap_w0
xfeed_17551 1 0 decap_w0
xfeed_17550 1 0 decap_w0
xfeed_13249 1 0 decap_w0
xfeed_13248 1 0 decap_w0
xfeed_13247 1 0 decap_w0
xfeed_13246 1 0 decap_w0
xfeed_13245 1 0 decap_w0
xfeed_13244 1 0 decap_w0
xfeed_13243 1 0 decap_w0
xfeed_13242 1 0 decap_w0
xfeed_13241 1 0 decap_w0
xfeed_13240 1 0 decap_w0
xfeed_12717 1 0 decap_w0
xfeed_12716 1 0 decap_w0
xfeed_12715 1 0 decap_w0
xfeed_12714 1 0 decap_w0
xfeed_12713 1 0 decap_w0
xfeed_12712 1 0 decap_w0
xfeed_12711 1 0 decap_w0
xfeed_12710 1 0 decap_w0
xfeed_5899 1 0 decap_w0
xfeed_5898 1 0 decap_w0
xfeed_5897 1 0 decap_w0
xfeed_5896 1 0 decap_w0
xfeed_5895 1 0 decap_w0
xfeed_5894 1 0 decap_w0
xfeed_5893 1 0 decap_w0
xfeed_5892 1 0 decap_w0
xfeed_5891 1 0 decap_w0
xfeed_30092 1 0 decap_w0
xfeed_30091 1 0 decap_w0
xfeed_30090 1 0 decap_w0
xfeed_17559 1 0 decap_w0
xfeed_17558 1 0 decap_w0
xfeed_17557 1 0 decap_w0
xfeed_12719 1 0 decap_w0
xfeed_12718 1 0 decap_w0
xfeed_7049 1 0 decap_w0
xfeed_7048 1 0 decap_w0
xfeed_7047 1 0 decap_w0
xfeed_7046 1 0 decap_w0
xfeed_7045 1 0 decap_w0
xfeed_7044 1 0 decap_w0
xfeed_7043 1 0 decap_w0
xfeed_7042 1 0 decap_w0
xfeed_7041 1 0 decap_w0
xfeed_7040 1 0 decap_w0
xfeed_6519 1 0 decap_w0
xfeed_6518 1 0 decap_w0
xfeed_6517 1 0 decap_w0
xfeed_6516 1 0 decap_w0
xfeed_6515 1 0 decap_w0
xfeed_6514 1 0 decap_w0
xfeed_6513 1 0 decap_w0
xfeed_6512 1 0 decap_w0
xfeed_6511 1 0 decap_w0
xfeed_6510 1 0 decap_w0
xfeed_2209 1 0 decap_w0
xfeed_2208 1 0 decap_w0
xfeed_2207 1 0 decap_w0
xfeed_2206 1 0 decap_w0
xfeed_2205 1 0 decap_w0
xfeed_2204 1 0 decap_w0
xfeed_2203 1 0 decap_w0
xfeed_2202 1 0 decap_w0
xfeed_2201 1 0 decap_w0
xfeed_2200 1 0 decap_w0
xspare_feed_139 1 0 tie
xspare_feed_138 1 0 decap_w0
xspare_feed_137 1 0 tie
xspare_feed_136 1 0 tie
xspare_feed_135 1 0 decap_w0
xspare_feed_134 1 0 tie
xspare_feed_133 1 0 tie
xspare_feed_132 1 0 decap_w0
xspare_feed_131 1 0 tie
xspare_feed_130 1 0 tie
xfeed_1590 1 0 decap_w0
xfeed_1591 1 0 decap_w0
xfeed_1592 1 0 decap_w0
xfeed_1593 1 0 decap_w0
xfeed_1594 1 0 decap_w0
xfeed_1595 1 0 decap_w0
xfeed_1596 1 0 decap_w0
xfeed_1597 1 0 decap_w0
xfeed_30099 1 0 decap_w0
xfeed_30098 1 0 decap_w0
xfeed_30097 1 0 decap_w0
xfeed_30096 1 0 decap_w0
xfeed_30095 1 0 decap_w0
xfeed_30094 1 0 decap_w0
xfeed_30093 1 0 decap_w0
xfeed_29019 1 0 decap_w0
xfeed_29018 1 0 decap_w0
xfeed_29017 1 0 decap_w0
xfeed_29016 1 0 decap_w0
xfeed_29015 1 0 decap_w0
xfeed_29014 1 0 decap_w0
xfeed_29013 1 0 decap_w0
xfeed_29012 1 0 decap_w0
xfeed_29011 1 0 decap_w0
xfeed_29010 1 0 decap_w0
xfeed_27879 1 0 decap_w0
xfeed_27878 1 0 decap_w0
xfeed_27877 1 0 decap_w0
xfeed_27876 1 0 decap_w0
xfeed_27875 1 0 decap_w0
xfeed_27874 1 0 decap_w0
xfeed_27873 1 0 decap_w0
xfeed_27872 1 0 decap_w0
xfeed_27871 1 0 decap_w0
xfeed_27870 1 0 decap_w0
xfeed_24099 1 0 decap_w0
xfeed_24098 1 0 decap_w0
xfeed_24097 1 0 decap_w0
xfeed_24096 1 0 decap_w0
xfeed_24095 1 0 decap_w0
xfeed_24094 1 0 decap_w0
xfeed_24093 1 0 decap_w0
xfeed_24092 1 0 decap_w0
xfeed_24091 1 0 decap_w0
xfeed_24090 1 0 decap_w0
xfeed_23569 1 0 decap_w0
xfeed_23568 1 0 decap_w0
xfeed_23567 1 0 decap_w0
xfeed_23566 1 0 decap_w0
xfeed_23565 1 0 decap_w0
xfeed_23564 1 0 decap_w0
xfeed_23563 1 0 decap_w0
xfeed_23562 1 0 decap_w0
xfeed_23561 1 0 decap_w0
xfeed_23560 1 0 decap_w0
xfeed_18099 1 0 decap_w0
xfeed_18098 1 0 decap_w0
xfeed_18097 1 0 decap_w0
xfeed_18096 1 0 decap_w0
xfeed_18095 1 0 decap_w0
xfeed_18094 1 0 decap_w0
xfeed_18093 1 0 decap_w0
xfeed_18092 1 0 decap_w0
xfeed_18091 1 0 decap_w0
xfeed_18090 1 0 decap_w0
xfeed_17563 1 0 decap_w0
xfeed_17562 1 0 decap_w0
xfeed_17561 1 0 decap_w0
xfeed_17560 1 0 decap_w0
xfeed_13259 1 0 decap_w0
xfeed_13258 1 0 decap_w0
xfeed_13257 1 0 decap_w0
xfeed_13256 1 0 decap_w0
xfeed_13255 1 0 decap_w0
xfeed_13254 1 0 decap_w0
xfeed_13253 1 0 decap_w0
xfeed_13252 1 0 decap_w0
xfeed_13251 1 0 decap_w0
xfeed_13250 1 0 decap_w0
xfeed_12724 1 0 decap_w0
xfeed_12723 1 0 decap_w0
xfeed_12722 1 0 decap_w0
xfeed_12721 1 0 decap_w0
xfeed_12720 1 0 decap_w0
xfeed_1598 1 0 decap_w0
xfeed_1599 1 0 decap_w0
xfeed_17569 1 0 decap_w0
xfeed_17568 1 0 decap_w0
xfeed_17567 1 0 decap_w0
xfeed_17566 1 0 decap_w0
xfeed_17565 1 0 decap_w0
xfeed_17564 1 0 decap_w0
xfeed_12729 1 0 decap_w0
xfeed_12728 1 0 decap_w0
xfeed_12727 1 0 decap_w0
xfeed_12726 1 0 decap_w0
xfeed_12725 1 0 decap_w0
xfeed_7059 1 0 decap_w0
xfeed_7058 1 0 decap_w0
xfeed_7057 1 0 decap_w0
xfeed_7056 1 0 decap_w0
xfeed_7055 1 0 decap_w0
xfeed_7054 1 0 decap_w0
xfeed_7053 1 0 decap_w0
xfeed_7052 1 0 decap_w0
xfeed_7051 1 0 decap_w0
xfeed_7050 1 0 decap_w0
xfeed_6529 1 0 decap_w0
xfeed_6528 1 0 decap_w0
xfeed_6527 1 0 decap_w0
xfeed_6526 1 0 decap_w0
xfeed_6525 1 0 decap_w0
xfeed_6524 1 0 decap_w0
xfeed_6523 1 0 decap_w0
xfeed_6522 1 0 decap_w0
xfeed_6521 1 0 decap_w0
xfeed_6520 1 0 decap_w0
xfeed_2219 1 0 decap_w0
xfeed_2218 1 0 decap_w0
xfeed_2217 1 0 decap_w0
xfeed_2216 1 0 decap_w0
xfeed_2215 1 0 decap_w0
xfeed_2214 1 0 decap_w0
xfeed_2213 1 0 decap_w0
xfeed_2212 1 0 decap_w0
xfeed_2211 1 0 decap_w0
xfeed_2210 1 0 decap_w0
xspare_feed_149 1 0 tie
xspare_feed_148 1 0 tie
xspare_feed_147 1 0 decap_w0
xspare_feed_146 1 0 tie
xspare_feed_145 1 0 tie
xspare_feed_144 1 0 decap_w0
xspare_feed_143 1 0 tie
xspare_feed_142 1 0 tie
xspare_feed_141 1 0 decap_w0
xspare_feed_140 1 0 tie
xfeed_29029 1 0 decap_w0
xfeed_29028 1 0 decap_w0
xfeed_29027 1 0 decap_w0
xfeed_29026 1 0 decap_w0
xfeed_29025 1 0 decap_w0
xfeed_29024 1 0 decap_w0
xfeed_29023 1 0 decap_w0
xfeed_29022 1 0 decap_w0
xfeed_29021 1 0 decap_w0
xfeed_29020 1 0 decap_w0
xfeed_27889 1 0 decap_w0
xfeed_27888 1 0 decap_w0
xfeed_27887 1 0 decap_w0
xfeed_27886 1 0 decap_w0
xfeed_27885 1 0 decap_w0
xfeed_27884 1 0 decap_w0
xfeed_27883 1 0 decap_w0
xfeed_27882 1 0 decap_w0
xfeed_27881 1 0 decap_w0
xfeed_27880 1 0 decap_w0
xfeed_23579 1 0 decap_w0
xfeed_23578 1 0 decap_w0
xfeed_23577 1 0 decap_w0
xfeed_23576 1 0 decap_w0
xfeed_23575 1 0 decap_w0
xfeed_23574 1 0 decap_w0
xfeed_23573 1 0 decap_w0
xfeed_23572 1 0 decap_w0
xfeed_23571 1 0 decap_w0
xfeed_23570 1 0 decap_w0
xfeed_17570 1 0 decap_w0
xfeed_13269 1 0 decap_w0
xfeed_13268 1 0 decap_w0
xfeed_13267 1 0 decap_w0
xfeed_13266 1 0 decap_w0
xfeed_13265 1 0 decap_w0
xfeed_13264 1 0 decap_w0
xfeed_13263 1 0 decap_w0
xfeed_13262 1 0 decap_w0
xfeed_13261 1 0 decap_w0
xfeed_13260 1 0 decap_w0
xfeed_12731 1 0 decap_w0
xfeed_12730 1 0 decap_w0
xfeed_17579 1 0 decap_w0
xfeed_17578 1 0 decap_w0
xfeed_17577 1 0 decap_w0
xfeed_17576 1 0 decap_w0
xfeed_17575 1 0 decap_w0
xfeed_17574 1 0 decap_w0
xfeed_17573 1 0 decap_w0
xfeed_17572 1 0 decap_w0
xfeed_17571 1 0 decap_w0
xfeed_12739 1 0 decap_w0
xfeed_12738 1 0 decap_w0
xfeed_12737 1 0 decap_w0
xfeed_12736 1 0 decap_w0
xfeed_12735 1 0 decap_w0
xfeed_12734 1 0 decap_w0
xfeed_12733 1 0 decap_w0
xfeed_12732 1 0 decap_w0
xfeed_7069 1 0 decap_w0
xfeed_7068 1 0 decap_w0
xfeed_7067 1 0 decap_w0
xfeed_7066 1 0 decap_w0
xfeed_7065 1 0 decap_w0
xfeed_7064 1 0 decap_w0
xfeed_7063 1 0 decap_w0
xfeed_7062 1 0 decap_w0
xfeed_7061 1 0 decap_w0
xfeed_7060 1 0 decap_w0
xfeed_6539 1 0 decap_w0
xfeed_6538 1 0 decap_w0
xfeed_6537 1 0 decap_w0
xfeed_6536 1 0 decap_w0
xfeed_6535 1 0 decap_w0
xfeed_6534 1 0 decap_w0
xfeed_6533 1 0 decap_w0
xfeed_6532 1 0 decap_w0
xfeed_6531 1 0 decap_w0
xfeed_6530 1 0 decap_w0
xfeed_2229 1 0 decap_w0
xfeed_2228 1 0 decap_w0
xfeed_2227 1 0 decap_w0
xfeed_2226 1 0 decap_w0
xfeed_2225 1 0 decap_w0
xfeed_2224 1 0 decap_w0
xfeed_2223 1 0 decap_w0
xfeed_2222 1 0 decap_w0
xfeed_2221 1 0 decap_w0
xfeed_2220 1 0 decap_w0
xspare_feed_159 1 0 decap_w0
xspare_feed_158 1 0 tie
xspare_feed_157 1 0 tie
xspare_feed_156 1 0 decap_w0
xspare_feed_155 1 0 tie
xspare_feed_154 1 0 tie
xspare_feed_153 1 0 decap_w0
xspare_feed_152 1 0 tie
xspare_feed_151 1 0 tie
xspare_feed_150 1 0 decap_w0
xfeed_29039 1 0 decap_w0
xfeed_29038 1 0 decap_w0
xfeed_29037 1 0 decap_w0
xfeed_29036 1 0 decap_w0
xfeed_29035 1 0 decap_w0
xfeed_29034 1 0 decap_w0
xfeed_29033 1 0 decap_w0
xfeed_29032 1 0 decap_w0
xfeed_29031 1 0 decap_w0
xfeed_29030 1 0 decap_w0
xfeed_28509 1 0 decap_w0
xfeed_28508 1 0 decap_w0
xfeed_28507 1 0 decap_w0
xfeed_28506 1 0 decap_w0
xfeed_28505 1 0 decap_w0
xfeed_28504 1 0 decap_w0
xfeed_28503 1 0 decap_w0
xfeed_28502 1 0 decap_w0
xfeed_28501 1 0 decap_w0
xfeed_28500 1 0 decap_w0
xfeed_27899 1 0 decap_w0
xfeed_27898 1 0 decap_w0
xfeed_27897 1 0 tie
xfeed_27896 1 0 decap_w0
xfeed_27895 1 0 decap_w0
xfeed_27894 1 0 decap_w0
xfeed_27893 1 0 decap_w0
xfeed_27892 1 0 decap_w0
xfeed_27891 1 0 decap_w0
xfeed_27890 1 0 decap_w0
xfeed_23589 1 0 decap_w0
xfeed_23588 1 0 decap_w0
xfeed_23587 1 0 decap_w0
xfeed_23586 1 0 decap_w0
xfeed_23585 1 0 decap_w0
xfeed_23584 1 0 decap_w0
xfeed_23583 1 0 decap_w0
xfeed_23582 1 0 decap_w0
xfeed_23581 1 0 decap_w0
xfeed_23580 1 0 decap_w0
xfeed_13277 1 0 decap_w0
xfeed_13276 1 0 decap_w0
xfeed_13275 1 0 decap_w0
xfeed_13274 1 0 decap_w0
xfeed_13273 1 0 decap_w0
xfeed_13272 1 0 tie
xfeed_13271 1 0 decap_w0
xfeed_13270 1 0 decap_w0
xfeed_209 1 0 decap_w0
xfeed_208 1 0 decap_w0
xfeed_207 1 0 decap_w0
xfeed_206 1 0 decap_w0
xfeed_205 1 0 decap_w0
xfeed_204 1 0 decap_w0
xfeed_200 1 0 decap_w0
xfeed_201 1 0 decap_w0
xfeed_202 1 0 decap_w0
xfeed_203 1 0 decap_w0
xfeed_30209 1 0 decap_w0
xfeed_30208 1 0 decap_w0
xfeed_30207 1 0 decap_w0
xfeed_30206 1 0 decap_w0
xfeed_30205 1 0 decap_w0
xfeed_30204 1 0 decap_w0
xfeed_30203 1 0 decap_w0
xfeed_30202 1 0 decap_w0
xfeed_30201 1 0 decap_w0
xfeed_30200 1 0 decap_w0
xfeed_17589 1 0 decap_w0
xfeed_17588 1 0 decap_w0
xfeed_17587 1 0 decap_w0
xfeed_17586 1 0 decap_w0
xfeed_17585 1 0 decap_w0
xfeed_17584 1 0 decap_w0
xfeed_17583 1 0 decap_w0
xfeed_17582 1 0 decap_w0
xfeed_17581 1 0 decap_w0
xfeed_17580 1 0 decap_w0
xfeed_13279 1 0 decap_w0
xfeed_13278 1 0 decap_w0
xfeed_12749 1 0 decap_w0
xfeed_12748 1 0 decap_w0
xfeed_12747 1 0 decap_w0
xfeed_12746 1 0 decap_w0
xfeed_12745 1 0 decap_w0
xfeed_12744 1 0 decap_w0
xfeed_12743 1 0 decap_w0
xfeed_12742 1 0 decap_w0
xfeed_12741 1 0 decap_w0
xfeed_12740 1 0 decap_w0
xfeed_7079 1 0 decap_w0
xfeed_7078 1 0 decap_w0
xfeed_7077 1 0 decap_w0
xfeed_7076 1 0 decap_w0
xfeed_7075 1 0 decap_w0
xfeed_7074 1 0 decap_w0
xfeed_7073 1 0 decap_w0
xfeed_7072 1 0 decap_w0
xfeed_7071 1 0 decap_w0
xfeed_7070 1 0 decap_w0
xfeed_6549 1 0 decap_w0
xfeed_6548 1 0 decap_w0
xfeed_6547 1 0 decap_w0
xfeed_6546 1 0 decap_w0
xfeed_6545 1 0 decap_w0
xfeed_6544 1 0 decap_w0
xfeed_6543 1 0 decap_w0
xfeed_6542 1 0 decap_w0
xfeed_6541 1 0 decap_w0
xfeed_6540 1 0 decap_w0
xfeed_2239 1 0 decap_w0
xfeed_2238 1 0 decap_w0
xfeed_2237 1 0 decap_w0
xfeed_2236 1 0 decap_w0
xfeed_2235 1 0 decap_w0
xfeed_2234 1 0 decap_w0
xfeed_2233 1 0 decap_w0
xfeed_2232 1 0 decap_w0
xfeed_2231 1 0 decap_w0
xfeed_2230 1 0 decap_w0
xspare_feed_161 1 0 tie
xspare_feed_160 1 0 tie
xspare_feed_162 1 0 decap_w0
xspare_feed_163 1 0 tie
xspare_feed_164 1 0 tie
xspare_feed_165 1 0 decap_w0
xspare_feed_166 1 0 tie
xspare_feed_167 1 0 tie
xspare_feed_168 1 0 decap_w0
xspare_feed_169 1 0 tie
xfeed_1700 1 0 decap_w0
xfeed_1701 1 0 decap_w0
xfeed_1702 1 0 decap_w0
xfeed_1703 1 0 decap_w0
xfeed_1704 1 0 decap_w0
xfeed_1705 1 0 decap_w0
xfeed_1706 1 0 decap_w0
xfeed_1707 1 0 decap_w0
xfeed_1708 1 0 decap_w0
xfeed_1709 1 0 decap_w0
xfeed_29049 1 0 decap_w0
xfeed_29048 1 0 decap_w0
xfeed_29047 1 0 decap_w0
xfeed_29046 1 0 decap_w0
xfeed_29045 1 0 decap_w0
xfeed_29044 1 0 decap_w0
xfeed_29043 1 0 decap_w0
xfeed_29042 1 0 decap_w0
xfeed_29041 1 0 decap_w0
xfeed_29040 1 0 decap_w0
xfeed_28519 1 0 decap_w0
xfeed_28518 1 0 decap_w0
xfeed_28517 1 0 decap_w0
xfeed_28516 1 0 decap_w0
xfeed_28515 1 0 decap_w0
xfeed_28514 1 0 decap_w0
xfeed_28513 1 0 decap_w0
xfeed_28512 1 0 decap_w0
xfeed_28511 1 0 decap_w0
xfeed_28510 1 0 decap_w0
xfeed_24209 1 0 decap_w0
xfeed_24208 1 0 decap_w0
xfeed_24207 1 0 decap_w0
xfeed_24206 1 0 decap_w0
xfeed_24205 1 0 decap_w0
xfeed_24204 1 0 decap_w0
xfeed_24203 1 0 decap_w0
xfeed_24202 1 0 decap_w0
xfeed_24201 1 0 decap_w0
xfeed_24200 1 0 decap_w0
xfeed_23599 1 0 decap_w0
xfeed_23598 1 0 decap_w0
xfeed_23597 1 0 decap_w0
xfeed_23596 1 0 decap_w0
xfeed_23595 1 0 decap_w0
xfeed_23594 1 0 decap_w0
xfeed_23593 1 0 decap_w0
xfeed_23592 1 0 decap_w0
xfeed_23591 1 0 decap_w0
xfeed_23590 1 0 decap_w0
xfeed_18209 1 0 decap_w0
xfeed_18208 1 0 decap_w0
xfeed_18207 1 0 decap_w0
xfeed_18206 1 0 decap_w0
xfeed_18205 1 0 decap_w0
xfeed_18204 1 0 decap_w0
xfeed_18203 1 0 decap_w0
xfeed_18202 1 0 decap_w0
xfeed_18201 1 0 decap_w0
xfeed_18200 1 0 decap_w0
xfeed_13284 1 0 decap_w0
xfeed_13283 1 0 decap_w0
xfeed_13282 1 0 decap_w0
xfeed_13281 1 0 decap_w0
xfeed_13280 1 0 decap_w0
xfeed_219 1 0 decap_w0
xfeed_218 1 0 decap_w0
xfeed_217 1 0 decap_w0
xfeed_216 1 0 decap_w0
xfeed_215 1 0 decap_w0
xfeed_214 1 0 decap_w0
xfeed_213 1 0 decap_w0
xfeed_212 1 0 decap_w0
xfeed_211 1 0 decap_w0
xfeed_210 1 0 decap_w0
xfeed_30218 1 0 decap_w0
xfeed_30217 1 0 decap_w0
xfeed_30216 1 0 decap_w0
xfeed_30215 1 0 decap_w0
xfeed_30214 1 0 decap_w0
xfeed_30213 1 0 decap_w0
xfeed_30212 1 0 decap_w0
xfeed_30211 1 0 decap_w0
xfeed_30210 1 0 decap_w0
xfeed_17599 1 0 decap_w0
xfeed_17598 1 0 decap_w0
xfeed_17597 1 0 decap_w0
xfeed_17596 1 0 decap_w0
xfeed_17595 1 0 decap_w0
xfeed_17594 1 0 decap_w0
xfeed_17593 1 0 decap_w0
xfeed_17592 1 0 decap_w0
xfeed_17591 1 0 decap_w0
xfeed_17590 1 0 decap_w0
xfeed_13289 1 0 decap_w0
xfeed_13288 1 0 decap_w0
xfeed_13287 1 0 decap_w0
xfeed_13286 1 0 decap_w0
xfeed_13285 1 0 decap_w0
xfeed_12759 1 0 decap_w0
xfeed_12758 1 0 decap_w0
xfeed_12757 1 0 decap_w0
xfeed_12756 1 0 decap_w0
xfeed_12755 1 0 decap_w0
xfeed_12754 1 0 decap_w0
xfeed_12753 1 0 decap_w0
xfeed_12752 1 0 decap_w0
xfeed_12751 1 0 decap_w0
xfeed_12750 1 0 decap_w0
xfeed_7089 1 0 decap_w0
xfeed_7088 1 0 decap_w0
xfeed_7087 1 0 decap_w0
xfeed_7086 1 0 decap_w0
xfeed_7085 1 0 decap_w0
xfeed_7084 1 0 decap_w0
xfeed_7083 1 0 decap_w0
xfeed_7082 1 0 decap_w0
xfeed_7081 1 0 decap_w0
xfeed_7080 1 0 decap_w0
xfeed_6559 1 0 decap_w0
xfeed_6558 1 0 decap_w0
xfeed_6557 1 0 decap_w0
xfeed_6556 1 0 decap_w0
xfeed_6555 1 0 decap_w0
xfeed_6554 1 0 decap_w0
xfeed_6553 1 0 decap_w0
xfeed_6552 1 0 decap_w0
xfeed_6551 1 0 decap_w0
xfeed_6550 1 0 decap_w0
xfeed_2249 1 0 decap_w0
xfeed_2248 1 0 decap_w0
xfeed_2247 1 0 decap_w0
xfeed_2246 1 0 decap_w0
xfeed_2245 1 0 decap_w0
xfeed_2244 1 0 decap_w0
xfeed_2243 1 0 decap_w0
xfeed_2242 1 0 decap_w0
xfeed_2241 1 0 decap_w0
xfeed_2240 1 0 decap_w0
xspare_feed_170 1 0 tie
xspare_feed_171 1 0 decap_w0
xspare_feed_172 1 0 tie
xspare_feed_173 1 0 tie
xspare_feed_174 1 0 decap_w0
xspare_feed_175 1 0 tie
xspare_feed_176 1 0 tie
xfeed_1710 1 0 decap_w0
xfeed_1711 1 0 decap_w0
xfeed_1712 1 0 decap_w0
xfeed_1713 1 0 decap_w0
xfeed_1714 1 0 decap_w0
xfeed_1715 1 0 decap_w0
xfeed_1716 1 0 decap_w0
xfeed_1717 1 0 decap_w0
xfeed_1718 1 0 decap_w0
xfeed_1719 1 0 decap_w0
xfeed_30219 1 0 decap_w0
xfeed_29059 1 0 decap_w0
xfeed_29058 1 0 decap_w0
xfeed_29057 1 0 decap_w0
xfeed_29056 1 0 decap_w0
xfeed_29055 1 0 decap_w0
xfeed_29054 1 0 decap_w0
xfeed_29053 1 0 decap_w0
xfeed_29052 1 0 decap_w0
xfeed_29051 1 0 decap_w0
xfeed_29050 1 0 decap_w0
xfeed_28529 1 0 decap_w0
xfeed_28528 1 0 decap_w0
xfeed_28527 1 0 decap_w0
xfeed_28526 1 0 decap_w0
xfeed_28525 1 0 decap_w0
xfeed_28524 1 0 decap_w0
xfeed_28523 1 0 decap_w0
xfeed_28522 1 0 decap_w0
xfeed_28521 1 0 decap_w0
xfeed_28520 1 0 decap_w0
xfeed_24219 1 0 decap_w0
xfeed_24218 1 0 decap_w0
xfeed_24217 1 0 decap_w0
xfeed_24216 1 0 decap_w0
xfeed_24215 1 0 decap_w0
xfeed_24214 1 0 decap_w0
xfeed_24213 1 0 decap_w0
xfeed_24212 1 0 decap_w0
xfeed_24211 1 0 decap_w0
xfeed_24210 1 0 decap_w0
xfeed_18219 1 0 decap_w0
xfeed_18218 1 0 decap_w0
xfeed_18217 1 0 decap_w0
xfeed_18216 1 0 decap_w0
xfeed_18215 1 0 decap_w0
xfeed_18214 1 0 decap_w0
xfeed_18213 1 0 decap_w0
xfeed_18212 1 0 decap_w0
xfeed_18211 1 0 decap_w0
xfeed_18210 1 0 decap_w0
xfeed_13291 1 0 decap_w0
xfeed_13290 1 0 decap_w0
xfeed_229 1 0 decap_w0
xfeed_228 1 0 decap_w0
xfeed_227 1 0 decap_w0
xfeed_226 1 0 decap_w0
xfeed_225 1 0 decap_w0
xfeed_224 1 0 decap_w0
xfeed_223 1 0 decap_w0
xfeed_222 1 0 decap_w0
xfeed_221 1 0 decap_w0
xfeed_220 1 0 decap_w0
xspare_feed_177 1 0 decap_w0
xspare_feed_178 1 0 tie
xspare_feed_179 1 0 tie
xfeed_30225 1 0 decap_w0
xfeed_30224 1 0 decap_w0
xfeed_30223 1 0 decap_w0
xfeed_30222 1 0 decap_w0
xfeed_30221 1 0 decap_w0
xfeed_30220 1 0 decap_w0
xfeed_13299 1 0 decap_w0
xfeed_13298 1 0 decap_w0
xfeed_13297 1 0 decap_w0
xfeed_13296 1 0 decap_w0
xfeed_13295 1 0 decap_w0
xfeed_13294 1 0 decap_w0
xfeed_13293 1 0 decap_w0
xfeed_13292 1 0 decap_w0
xfeed_12769 1 0 decap_w0
xfeed_12768 1 0 decap_w0
xfeed_12767 1 0 decap_w0
xfeed_12766 1 0 decap_w0
xfeed_12765 1 0 decap_w0
xfeed_12764 1 0 decap_w0
xfeed_12763 1 0 decap_w0
xfeed_12762 1 0 decap_w0
xfeed_12761 1 0 decap_w0
xfeed_12760 1 0 decap_w0
xfeed_7099 1 0 decap_w0
xfeed_7098 1 0 decap_w0
xfeed_7097 1 0 decap_w0
xfeed_7096 1 0 decap_w0
xfeed_7095 1 0 decap_w0
xfeed_7094 1 0 decap_w0
xfeed_7093 1 0 decap_w0
xfeed_7092 1 0 decap_w0
xfeed_7091 1 0 decap_w0
xfeed_7090 1 0 decap_w0
xfeed_6569 1 0 decap_w0
xfeed_6568 1 0 decap_w0
xfeed_6567 1 0 decap_w0
xfeed_6566 1 0 decap_w0
xfeed_6565 1 0 decap_w0
xfeed_6564 1 0 decap_w0
xfeed_6563 1 0 decap_w0
xfeed_6562 1 0 decap_w0
xfeed_6561 1 0 decap_w0
xfeed_6560 1 0 decap_w0
xfeed_2259 1 0 decap_w0
xfeed_2258 1 0 decap_w0
xfeed_2257 1 0 decap_w0
xfeed_2256 1 0 decap_w0
xfeed_2255 1 0 decap_w0
xfeed_2254 1 0 decap_w0
xfeed_2253 1 0 decap_w0
xfeed_2252 1 0 decap_w0
xfeed_2251 1 0 decap_w0
xfeed_2250 1 0 decap_w0
xspare_feed_180 1 0 decap_w0
xspare_feed_181 1 0 tie
xspare_feed_182 1 0 tie
xspare_feed_183 1 0 decap_w0
xfeed_1720 1 0 decap_w0
xfeed_1721 1 0 decap_w0
xfeed_1722 1 0 decap_w0
xfeed_1723 1 0 decap_w0
xfeed_1724 1 0 decap_w0
xfeed_1725 1 0 decap_w0
xfeed_1726 1 0 decap_w0
xfeed_1727 1 0 decap_w0
xfeed_1728 1 0 decap_w0
xfeed_1729 1 0 decap_w0
xfeed_30229 1 0 decap_w0
xfeed_30228 1 0 decap_w0
xfeed_30227 1 0 decap_w0
xfeed_30226 1 0 decap_w0
xfeed_29069 1 0 decap_w0
xfeed_29068 1 0 decap_w0
xfeed_29067 1 0 decap_w0
xfeed_29066 1 0 decap_w0
xfeed_29065 1 0 decap_w0
xfeed_29064 1 0 decap_w0
xfeed_29063 1 0 decap_w0
xfeed_29062 1 0 decap_w0
xfeed_29061 1 0 decap_w0
xfeed_29060 1 0 decap_w0
xfeed_28539 1 0 decap_w0
xfeed_28538 1 0 decap_w0
xfeed_28537 1 0 decap_w0
xfeed_28536 1 0 decap_w0
xfeed_28535 1 0 decap_w0
xfeed_28534 1 0 decap_w0
xfeed_28533 1 0 decap_w0
xfeed_28532 1 0 decap_w0
xfeed_28531 1 0 decap_w0
xfeed_28530 1 0 decap_w0
xfeed_24229 1 0 decap_w0
xfeed_24228 1 0 decap_w0
xfeed_24227 1 0 decap_w0
xfeed_24226 1 0 decap_w0
xfeed_24225 1 0 decap_w0
xfeed_24224 1 0 decap_w0
xfeed_24223 1 0 decap_w0
xfeed_24222 1 0 decap_w0
xfeed_24221 1 0 decap_w0
xfeed_24220 1 0 decap_w0
xfeed_18229 1 0 decap_w0
xfeed_18228 1 0 decap_w0
xfeed_18227 1 0 decap_w0
xfeed_18226 1 0 decap_w0
xfeed_18225 1 0 decap_w0
xfeed_18224 1 0 decap_w0
xfeed_18223 1 0 decap_w0
xfeed_18222 1 0 decap_w0
xfeed_18221 1 0 decap_w0
xfeed_18220 1 0 decap_w0
xfeed_239 1 0 decap_w0
xfeed_238 1 0 decap_w0
xfeed_237 1 0 decap_w0
xfeed_236 1 0 decap_w0
xfeed_235 1 0 decap_w0
xfeed_234 1 0 decap_w0
xfeed_233 1 0 decap_w0
xfeed_232 1 0 decap_w0
xfeed_231 1 0 decap_w0
xfeed_230 1 0 decap_w0
xspare_feed_184 1 0 tie
xspare_feed_185 1 0 tie
xspare_feed_186 1 0 decap_w0
xspare_feed_187 1 0 tie
xspare_feed_188 1 0 tie
xspare_feed_189 1 0 decap_w0
xfeed_30232 1 0 decap_w0
xfeed_30231 1 0 decap_w0
xfeed_30230 1 0 decap_w0
xfeed_12779 1 0 decap_w0
xfeed_12778 1 0 decap_w0
xfeed_12777 1 0 decap_w0
xfeed_12776 1 0 decap_w0
xfeed_12775 1 0 decap_w0
xfeed_12774 1 0 decap_w0
xfeed_12773 1 0 decap_w0
xfeed_12772 1 0 decap_w0
xfeed_12771 1 0 decap_w0
xfeed_12770 1 0 decap_w0
xfeed_6576 1 0 decap_w0
xfeed_6575 1 0 decap_w0
xfeed_6574 1 0 decap_w0
xfeed_6573 1 0 decap_w0
xfeed_6572 1 0 decap_w0
xfeed_6571 1 0 decap_w0
xfeed_6570 1 0 decap_w0
xfeed_2269 1 0 decap_w0
xfeed_2268 1 0 decap_w0
xfeed_2267 1 0 decap_w0
xfeed_2266 1 0 decap_w0
xfeed_2265 1 0 decap_w0
xfeed_2264 1 0 decap_w0
xfeed_2263 1 0 decap_w0
xfeed_2262 1 0 decap_w0
xfeed_2261 1 0 decap_w0
xfeed_2260 1 0 decap_w0
xspare_feed_190 1 0 tie
xfeed_1730 1 0 decap_w0
xfeed_1731 1 0 decap_w0
xfeed_1732 1 0 decap_w0
xfeed_1733 1 0 decap_w0
xfeed_1734 1 0 decap_w0
xfeed_1735 1 0 decap_w0
xfeed_1736 1 0 decap_w0
xfeed_1737 1 0 decap_w0
xfeed_30239 1 0 decap_w0
xfeed_30238 1 0 decap_w0
xfeed_30237 1 0 decap_w0
xfeed_30236 1 0 decap_w0
xfeed_30235 1 0 decap_w0
xfeed_30234 1 0 decap_w0
xfeed_30233 1 0 decap_w0
xfeed_29079 1 0 decap_w0
xfeed_29078 1 0 decap_w0
xfeed_29077 1 0 decap_w0
xfeed_29076 1 0 decap_w0
xfeed_29075 1 0 decap_w0
xfeed_29074 1 0 decap_w0
xfeed_29073 1 0 decap_w0
xfeed_29072 1 0 decap_w0
xfeed_29071 1 0 decap_w0
xfeed_29070 1 0 decap_w0
xfeed_28549 1 0 decap_w0
xfeed_28548 1 0 decap_w0
xfeed_28547 1 0 decap_w0
xfeed_28546 1 0 decap_w0
xfeed_28545 1 0 decap_w0
xfeed_28544 1 0 decap_w0
xfeed_28543 1 0 decap_w0
xfeed_28542 1 0 decap_w0
xfeed_28541 1 0 decap_w0
xfeed_28540 1 0 decap_w0
xfeed_24239 1 0 decap_w0
xfeed_24238 1 0 decap_w0
xfeed_24237 1 0 decap_w0
xfeed_24236 1 0 decap_w0
xfeed_24235 1 0 decap_w0
xfeed_24234 1 0 decap_w0
xfeed_24233 1 0 decap_w0
xfeed_24232 1 0 decap_w0
xfeed_24231 1 0 decap_w0
xfeed_24230 1 0 decap_w0
xfeed_23709 1 0 decap_w0
xfeed_23708 1 0 decap_w0
xfeed_23707 1 0 decap_w0
xfeed_23706 1 0 decap_w0
xfeed_23705 1 0 decap_w0
xfeed_23704 1 0 decap_w0
xfeed_23703 1 0 decap_w0
xfeed_23702 1 0 decap_w0
xfeed_23701 1 0 decap_w0
xfeed_23700 1 0 decap_w0
xfeed_18239 1 0 decap_w0
xfeed_18238 1 0 decap_w0
xfeed_18237 1 0 decap_w0
xfeed_18236 1 0 decap_w0
xfeed_18235 1 0 decap_w0
xfeed_18234 1 0 decap_w0
xfeed_18233 1 0 decap_w0
xfeed_18232 1 0 decap_w0
xfeed_18231 1 0 decap_w0
xfeed_18230 1 0 decap_w0
xfeed_17703 1 0 decap_w0
xfeed_17702 1 0 decap_w0
xfeed_17701 1 0 decap_w0
xfeed_17700 1 0 decap_w0
xfeed_6579 1 0 decap_w0
xfeed_6578 1 0 decap_w0
xfeed_6577 1 0 decap_w0
xfeed_249 1 0 decap_w0
xfeed_248 1 0 decap_w0
xfeed_247 1 0 decap_w0
xfeed_246 1 0 decap_w0
xfeed_245 1 0 decap_w0
xfeed_244 1 0 decap_w0
xfeed_243 1 0 decap_w0
xfeed_242 1 0 decap_w0
xfeed_241 1 0 decap_w0
xfeed_240 1 0 decap_w0
xspare_feed_191 1 0 tie
xspare_feed_192 1 0 decap_w0
xspare_feed_193 1 0 tie
xspare_feed_194 1 0 tie
xspare_feed_195 1 0 decap_w0
xspare_feed_197 1 0 tie
xspare_feed_198 1 0 decap_w0
xspare_feed_199 1 0 tie
xfeed_0 1 0 decap_w0
xfeed_1738 1 0 decap_w0
xfeed_1739 1 0 decap_w0
xfeed_17709 1 0 decap_w0
xfeed_17708 1 0 decap_w0
xfeed_17707 1 0 decap_w0
xfeed_17706 1 0 decap_w0
xfeed_17705 1 0 decap_w0
xfeed_17704 1 0 decap_w0
xfeed_12789 1 0 decap_w0
xfeed_12788 1 0 decap_w0
xfeed_12787 1 0 decap_w0
xfeed_12786 1 0 decap_w0
xfeed_12785 1 0 decap_w0
xfeed_12784 1 0 decap_w0
xfeed_12783 1 0 decap_w0
xfeed_12782 1 0 decap_w0
xfeed_12781 1 0 decap_w0
xfeed_12780 1 0 decap_w0
xfeed_6583 1 0 decap_w0
xfeed_6582 1 0 decap_w0
xfeed_6581 1 0 decap_w0
xfeed_6580 1 0 decap_w0
xfeed_2279 1 0 decap_w0
xfeed_2278 1 0 decap_w0
xfeed_2277 1 0 decap_w0
xfeed_2276 1 0 decap_w0
xfeed_2275 1 0 decap_w0
xfeed_2274 1 0 decap_w0
xfeed_2273 1 0 decap_w0
xfeed_2272 1 0 decap_w0
xfeed_2271 1 0 decap_w0
xfeed_2270 1 0 decap_w0
xfeed_1 1 0 decap_w0
xfeed_2 1 0 decap_w0
xfeed_3 1 0 decap_w0
xfeed_4 1 0 decap_w0
xfeed_5 1 0 decap_w0
xfeed_6 1 0 decap_w0
xfeed_7 1 0 decap_w0
xfeed_8 1 0 decap_w0
xfeed_9 1 0 decap_w0
xfeed_1740 1 0 decap_w0
xfeed_1741 1 0 decap_w0
xfeed_1742 1 0 decap_w0
xfeed_1743 1 0 decap_w0
xfeed_1744 1 0 decap_w0
xfeed_30249 1 0 decap_w0
xfeed_30248 1 0 decap_w0
xfeed_30247 1 0 decap_w0
xfeed_30246 1 0 decap_w0
xfeed_30245 1 0 decap_w0
xfeed_30244 1 0 decap_w0
xfeed_30243 1 0 decap_w0
xfeed_30242 1 0 decap_w0
xfeed_30241 1 0 decap_w0
xfeed_30240 1 0 decap_w0
xfeed_29089 1 0 decap_w0
xfeed_29088 1 0 decap_w0
xfeed_29087 1 0 decap_w0
xfeed_29086 1 0 decap_w0
xfeed_29085 1 0 decap_w0
xfeed_29084 1 0 decap_w0
xfeed_29083 1 0 decap_w0
xfeed_29082 1 0 decap_w0
xfeed_29081 1 0 decap_w0
xfeed_29080 1 0 decap_w0
xfeed_28559 1 0 decap_w0
xfeed_28558 1 0 decap_w0
xfeed_28557 1 0 decap_w0
xfeed_28556 1 0 decap_w0
xfeed_28555 1 0 decap_w0
xfeed_28554 1 0 decap_w0
xfeed_28553 1 0 decap_w0
xfeed_28552 1 0 decap_w0
xfeed_28551 1 0 decap_w0
xfeed_28550 1 0 decap_w0
xfeed_24249 1 0 decap_w0
xfeed_24248 1 0 decap_w0
xfeed_24247 1 0 decap_w0
xfeed_24246 1 0 decap_w0
xfeed_24245 1 0 decap_w0
xfeed_24244 1 0 decap_w0
xfeed_24243 1 0 decap_w0
xfeed_24242 1 0 decap_w0
xfeed_24241 1 0 decap_w0
xfeed_24240 1 0 decap_w0
xfeed_23719 1 0 decap_w0
xfeed_23718 1 0 decap_w0
xfeed_23717 1 0 decap_w0
xfeed_23716 1 0 decap_w0
xfeed_23715 1 0 tie
xfeed_23714 1 0 decap_w0
xfeed_23713 1 0 decap_w0
xfeed_23712 1 0 decap_w0
xfeed_23711 1 0 decap_w0
xfeed_23710 1 0 decap_w0
xfeed_18249 1 0 decap_w0
xfeed_18248 1 0 decap_w0
xfeed_18247 1 0 decap_w0
xfeed_18246 1 0 decap_w0
xfeed_18245 1 0 decap_w0
xfeed_18244 1 0 decap_w0
xfeed_18243 1 0 decap_w0
xfeed_18242 1 0 decap_w0
xfeed_18241 1 0 decap_w0
xfeed_18240 1 0 decap_w0
xfeed_17710 1 0 decap_w0
xfeed_13409 1 0 decap_w0
xfeed_13408 1 0 decap_w0
xfeed_13407 1 0 decap_w0
xfeed_13406 1 0 decap_w0
xfeed_13405 1 0 decap_w0
xfeed_13404 1 0 decap_w0
xfeed_13403 1 0 decap_w0
xfeed_13402 1 0 decap_w0
xfeed_13401 1 0 decap_w0
xfeed_13400 1 0 decap_w0
xfeed_6589 1 0 decap_w0
xfeed_6588 1 0 decap_w0
xfeed_6587 1 0 decap_w0
xfeed_6586 1 0 decap_w0
xfeed_6585 1 0 decap_w0
xfeed_6584 1 0 decap_w0
xfeed_259 1 0 decap_w0
xfeed_258 1 0 decap_w0
xfeed_257 1 0 decap_w0
xfeed_256 1 0 decap_w0
xfeed_255 1 0 decap_w0
xfeed_254 1 0 decap_w0
xfeed_253 1 0 decap_w0
xfeed_252 1 0 decap_w0
xfeed_251 1 0 decap_w0
xfeed_250 1 0 decap_w0
xfeed_1745 1 0 decap_w0
xfeed_1746 1 0 decap_w0
xfeed_1747 1 0 decap_w0
xfeed_1748 1 0 decap_w0
xfeed_1749 1 0 decap_w0
xfeed_17719 1 0 decap_w0
xfeed_17718 1 0 decap_w0
xfeed_17717 1 0 decap_w0
xfeed_17716 1 0 decap_w0
xfeed_17715 1 0 decap_w0
xfeed_17714 1 0 decap_w0
xfeed_17713 1 0 decap_w0
xfeed_17712 1 0 decap_w0
xfeed_17711 1 0 decap_w0
xfeed_12799 1 0 decap_w0
xfeed_12798 1 0 decap_w0
xfeed_12797 1 0 decap_w0
xfeed_12796 1 0 decap_w0
xfeed_12795 1 0 decap_w0
xfeed_12794 1 0 decap_w0
xfeed_12793 1 0 decap_w0
xfeed_12792 1 0 decap_w0
xfeed_12791 1 0 decap_w0
xfeed_12790 1 0 decap_w0
xfeed_7209 1 0 decap_w0
xfeed_7208 1 0 decap_w0
xfeed_7207 1 0 decap_w0
xfeed_7206 1 0 decap_w0
xfeed_7205 1 0 decap_w0
xfeed_7204 1 0 decap_w0
xfeed_7203 1 0 decap_w0
xfeed_7202 1 0 decap_w0
xfeed_7201 1 0 decap_w0
xfeed_7200 1 0 decap_w0
xfeed_6590 1 0 decap_w0
xfeed_2289 1 0 decap_w0
xfeed_2288 1 0 decap_w0
xfeed_2287 1 0 decap_w0
xfeed_2286 1 0 decap_w0
xfeed_2285 1 0 decap_w0
xfeed_2284 1 0 decap_w0
xfeed_2283 1 0 decap_w0
xfeed_2282 1 0 decap_w0
xfeed_2281 1 0 decap_w0
xfeed_2280 1 0 decap_w0
xfeed_1750 1 0 decap_w0
xfeed_1751 1 0 decap_w0
xfeed_30259 1 0 decap_w0
xfeed_30258 1 0 decap_w0
xfeed_30257 1 0 decap_w0
xfeed_30256 1 0 decap_w0
xfeed_30255 1 0 decap_w0
xfeed_30254 1 0 decap_w0
xfeed_30253 1 0 decap_w0
xfeed_30252 1 0 decap_w0
xfeed_30251 1 0 decap_w0
xfeed_30250 1 0 decap_w0
xfeed_29099 1 0 decap_w0
xfeed_29098 1 0 decap_w0
xfeed_29097 1 0 decap_w0
xfeed_29096 1 0 decap_w0
xfeed_29095 1 0 decap_w0
xfeed_29094 1 0 decap_w0
xfeed_29093 1 0 decap_w0
xfeed_29092 1 0 decap_w0
xfeed_29091 1 0 decap_w0
xfeed_29090 1 0 decap_w0
xfeed_28569 1 0 decap_w0
xfeed_28568 1 0 decap_w0
xfeed_28567 1 0 decap_w0
xfeed_28566 1 0 decap_w0
xfeed_28565 1 0 decap_w0
xfeed_28564 1 0 decap_w0
xfeed_28563 1 0 decap_w0
xfeed_28562 1 0 decap_w0
xfeed_28561 1 0 decap_w0
xfeed_28560 1 0 decap_w0
xfeed_24259 1 0 decap_w0
xfeed_24258 1 0 decap_w0
xfeed_24257 1 0 decap_w0
xfeed_24256 1 0 decap_w0
xfeed_24255 1 0 decap_w0
xfeed_24254 1 0 decap_w0
xfeed_24253 1 0 decap_w0
xfeed_24252 1 0 decap_w0
xfeed_24251 1 0 decap_w0
xfeed_24250 1 0 decap_w0
xfeed_23729 1 0 decap_w0
xfeed_23728 1 0 decap_w0
xfeed_23727 1 0 decap_w0
xfeed_23726 1 0 decap_w0
xfeed_23725 1 0 decap_w0
xfeed_23724 1 0 decap_w0
xfeed_23723 1 0 decap_w0
xfeed_23722 1 0 decap_w0
xfeed_23721 1 0 decap_w0
xfeed_23720 1 0 decap_w0
xfeed_18256 1 0 decap_w0
xfeed_18255 1 0 decap_w0
xfeed_18254 1 0 decap_w0
xfeed_18253 1 0 decap_w0
xfeed_18252 1 0 decap_w0
xfeed_18251 1 0 decap_w0
xfeed_18250 1 0 decap_w0
xfeed_13417 1 0 decap_w0
xfeed_13416 1 0 decap_w0
xfeed_13415 1 0 decap_w0
xfeed_13414 1 0 decap_w0
xfeed_13413 1 0 decap_w0
xfeed_13412 1 0 decap_w0
xfeed_13411 1 0 decap_w0
xfeed_13410 1 0 decap_w0
xfeed_6599 1 0 decap_w0
xfeed_6598 1 0 decap_w0
xfeed_6597 1 0 decap_w0
xfeed_6596 1 0 decap_w0
xfeed_6595 1 0 decap_w0
xfeed_6594 1 0 decap_w0
xfeed_6593 1 0 decap_w0
xfeed_6592 1 0 decap_w0
xfeed_6591 1 0 decap_w0
xfeed_269 1 0 decap_w0
xfeed_268 1 0 decap_w0
xfeed_267 1 0 decap_w0
xfeed_266 1 0 decap_w0
xfeed_265 1 0 decap_w0
xfeed_264 1 0 decap_w0
xfeed_263 1 0 decap_w0
xfeed_262 1 0 decap_w0
xfeed_261 1 0 decap_w0
xfeed_260 1 0 decap_w0
xfeed_1752 1 0 decap_w0
xfeed_1753 1 0 decap_w0
xfeed_1754 1 0 decap_w0
xfeed_1755 1 0 decap_w0
xfeed_1756 1 0 decap_w0
xfeed_1757 1 0 decap_w0
xfeed_1758 1 0 decap_w0
xfeed_1759 1 0 decap_w0
xfeed_18259 1 0 decap_w0
xfeed_18258 1 0 decap_w0
xfeed_18257 1 0 decap_w0
xfeed_17729 1 0 decap_w0
xfeed_17728 1 0 decap_w0
xfeed_17727 1 0 decap_w0
xfeed_17726 1 0 decap_w0
xfeed_17725 1 0 decap_w0
xfeed_17724 1 0 decap_w0
xfeed_17723 1 0 decap_w0
xfeed_17722 1 0 decap_w0
xfeed_17721 1 0 decap_w0
xfeed_17720 1 0 decap_w0
xfeed_13419 1 0 decap_w0
xfeed_13418 1 0 decap_w0
xfeed_7219 1 0 decap_w0
xfeed_7218 1 0 decap_w0
xfeed_7217 1 0 decap_w0
xfeed_7216 1 0 decap_w0
xfeed_7215 1 0 decap_w0
xfeed_7214 1 0 decap_w0
xfeed_7213 1 0 decap_w0
xfeed_7212 1 0 decap_w0
xfeed_7211 1 0 decap_w0
xfeed_7210 1 0 decap_w0
xfeed_2297 1 0 decap_w0
xfeed_2296 1 0 decap_w0
xfeed_2295 1 0 decap_w0
xfeed_2294 1 0 decap_w0
xfeed_2293 1 0 decap_w0
xfeed_2292 1 0 decap_w0
xfeed_2291 1 0 decap_w0
xfeed_2290 1 0 decap_w0
xspare_feed_300 1 0 decap_w0
xspare_feed_301 1 0 tie
xspare_feed_302 1 0 tie
xspare_feed_303 1 0 decap_w0
xspare_feed_304 1 0 tie
xspare_feed_305 1 0 tie
xspare_feed_306 1 0 decap_w0
xspare_feed_307 1 0 tie
xspare_feed_308 1 0 tie
xspare_feed_309 1 0 decap_w0
xfeed_30269 1 0 decap_w0
xfeed_30268 1 0 decap_w0
xfeed_30267 1 0 decap_w0
xfeed_30266 1 0 decap_w0
xfeed_30265 1 0 decap_w0
xfeed_30264 1 0 decap_w0
xfeed_30263 1 0 decap_w0
xfeed_30262 1 0 decap_w0
xfeed_30261 1 0 decap_w0
xfeed_30260 1 0 decap_w0
xfeed_28579 1 0 decap_w0
xfeed_28578 1 0 decap_w0
xfeed_28577 1 0 decap_w0
xfeed_28576 1 0 decap_w0
xfeed_28575 1 0 decap_w0
xfeed_28574 1 0 decap_w0
xfeed_28573 1 0 decap_w0
xfeed_28572 1 0 decap_w0
xfeed_28571 1 0 decap_w0
xfeed_28570 1 0 decap_w0
xfeed_24269 1 0 decap_w0
xfeed_24268 1 0 tie
xfeed_24267 1 0 decap_w0
xfeed_24266 1 0 decap_w0
xfeed_24265 1 0 decap_w0
xfeed_24264 1 0 decap_w0
xfeed_24263 1 0 decap_w0
xfeed_24262 1 0 decap_w0
xfeed_24261 1 0 decap_w0
xfeed_24260 1 0 decap_w0
xfeed_23739 1 0 decap_w0
xfeed_23738 1 0 decap_w0
xfeed_23737 1 0 decap_w0
xfeed_23736 1 0 decap_w0
xfeed_23735 1 0 decap_w0
xfeed_23734 1 0 decap_w0
xfeed_23733 1 0 decap_w0
xfeed_23732 1 0 decap_w0
xfeed_23731 1 0 decap_w0
xfeed_23730 1 0 decap_w0
xfeed_18263 1 0 decap_w0
xfeed_18262 1 0 decap_w0
xfeed_18261 1 0 decap_w0
xfeed_18260 1 0 decap_w0
xfeed_13424 1 0 decap_w0
xfeed_13423 1 0 decap_w0
xfeed_13422 1 0 decap_w0
xfeed_13421 1 0 decap_w0
xfeed_13420 1 0 decap_w0
xfeed_2299 1 0 decap_w0
xfeed_2298 1 0 decap_w0
xfeed_279 1 0 decap_w0
xfeed_278 1 0 decap_w0
xfeed_277 1 0 decap_w0
xfeed_276 1 0 decap_w0
xfeed_275 1 0 decap_w0
xfeed_274 1 0 decap_w0
xfeed_273 1 0 decap_w0
xfeed_272 1 0 decap_w0
xfeed_271 1 0 decap_w0
xfeed_270 1 0 decap_w0
xfeed_1760 1 0 decap_w0
xfeed_1761 1 0 decap_w0
xfeed_1762 1 0 decap_w0
xfeed_1763 1 0 decap_w0
xfeed_1764 1 0 decap_w0
xfeed_1765 1 0 decap_w0
xfeed_1766 1 0 decap_w0
xfeed_1767 1 0 decap_w0
xfeed_1768 1 0 decap_w0
xfeed_1769 1 0 decap_w0
xfeed_18269 1 0 tie
xfeed_18268 1 0 decap_w0
xfeed_18267 1 0 decap_w0
xfeed_18266 1 0 decap_w0
xfeed_18265 1 0 decap_w0
xfeed_18264 1 0 decap_w0
xfeed_17739 1 0 decap_w0
xfeed_17738 1 0 decap_w0
xfeed_17737 1 0 decap_w0
xfeed_17736 1 0 decap_w0
xfeed_17735 1 0 decap_w0
xfeed_17734 1 0 decap_w0
xfeed_17733 1 0 decap_w0
xfeed_17732 1 0 decap_w0
xfeed_17731 1 0 decap_w0
xfeed_17730 1 0 decap_w0
xfeed_13429 1 0 decap_w0
xfeed_13428 1 0 decap_w0
xfeed_13427 1 0 decap_w0
xfeed_13426 1 0 decap_w0
xfeed_13425 1 0 decap_w0
xfeed_7229 1 0 decap_w0
xfeed_7228 1 0 decap_w0
xfeed_7227 1 0 decap_w0
xfeed_7226 1 0 decap_w0
xfeed_7225 1 0 decap_w0
xfeed_7224 1 0 decap_w0
xfeed_7223 1 0 decap_w0
xfeed_7222 1 0 decap_w0
xfeed_7221 1 0 decap_w0
xfeed_7220 1 0 decap_w0
xspare_feed_310 1 0 tie
xspare_feed_311 1 0 tie
xspare_feed_312 1 0 decap_w0
xspare_feed_313 1 0 tie
xspare_feed_314 1 0 tie
xspare_feed_315 1 0 decap_w0
xspare_feed_316 1 0 tie
xfeed_30279 1 0 decap_w0
xfeed_30278 1 0 decap_w0
xfeed_30277 1 0 decap_w0
xfeed_30276 1 0 decap_w0
xfeed_30275 1 0 decap_w0
xfeed_30274 1 0 decap_w0
xfeed_30273 1 0 decap_w0
xfeed_30272 1 0 decap_w0
xfeed_30271 1 0 decap_w0
xfeed_30270 1 0 decap_w0
xfeed_28589 1 0 decap_w0
xfeed_28588 1 0 decap_w0
xfeed_28587 1 0 decap_w0
xfeed_28586 1 0 decap_w0
xfeed_28585 1 0 decap_w0
xfeed_28584 1 0 decap_w0
xfeed_28583 1 0 decap_w0
xfeed_28582 1 0 decap_w0
xfeed_28581 1 0 decap_w0
xfeed_28580 1 0 decap_w0
xfeed_24279 1 0 decap_w0
xfeed_24278 1 0 decap_w0
xfeed_24277 1 0 decap_w0
xfeed_24276 1 0 decap_w0
xfeed_24275 1 0 decap_w0
xfeed_24274 1 0 decap_w0
xfeed_24273 1 0 decap_w0
xfeed_24272 1 0 decap_w0
xfeed_24271 1 0 decap_w0
xfeed_24270 1 0 decap_w0
xfeed_23749 1 0 decap_w0
xfeed_23748 1 0 decap_w0
xfeed_23747 1 0 decap_w0
xfeed_23746 1 0 decap_w0
xfeed_23745 1 0 decap_w0
xfeed_23744 1 0 decap_w0
xfeed_23743 1 0 decap_w0
xfeed_23742 1 0 decap_w0
xfeed_23741 1 0 decap_w0
xfeed_23740 1 0 decap_w0
xfeed_18270 1 0 decap_w0
xfeed_13431 1 0 decap_w0
xfeed_13430 1 0 decap_w0
xfeed_289 1 0 decap_w0
xfeed_288 1 0 decap_w0
xfeed_287 1 0 decap_w0
xfeed_286 1 0 decap_w0
xfeed_285 1 0 decap_w0
xfeed_284 1 0 decap_w0
xfeed_283 1 0 decap_w0
xfeed_282 1 0 decap_w0
xfeed_281 1 0 decap_w0
xfeed_280 1 0 decap_w0
xspare_feed_317 1 0 tie
xspare_feed_318 1 0 decap_w0
xspare_feed_319 1 0 tie
xfeed_1770 1 0 decap_w0
xfeed_1771 1 0 decap_w0
xfeed_1772 1 0 decap_w0
xfeed_1773 1 0 decap_w0
xfeed_1774 1 0 decap_w0
xfeed_1775 1 0 decap_w0
xfeed_1776 1 0 decap_w0
xfeed_1777 1 0 decap_w0
xfeed_1778 1 0 decap_w0
xfeed_1779 1 0 decap_w0
xfeed_18279 1 0 decap_w0
xfeed_18278 1 0 decap_w0
xfeed_18277 1 0 decap_w0
xfeed_18276 1 0 decap_w0
xfeed_18275 1 0 decap_w0
xfeed_18274 1 0 decap_w0
xfeed_18273 1 0 decap_w0
xfeed_18272 1 0 decap_w0
xfeed_18271 1 0 decap_w0
xfeed_17749 1 0 decap_w0
xfeed_17748 1 0 decap_w0
xfeed_17747 1 0 decap_w0
xfeed_17746 1 0 decap_w0
xfeed_17745 1 0 decap_w0
xfeed_17744 1 0 decap_w0
xfeed_17743 1 0 decap_w0
xfeed_17742 1 0 decap_w0
xfeed_17741 1 0 decap_w0
xfeed_17740 1 0 decap_w0
xfeed_13439 1 0 decap_w0
xfeed_13438 1 0 decap_w0
xfeed_13437 1 0 decap_w0
xfeed_13436 1 0 decap_w0
xfeed_13435 1 0 decap_w0
xfeed_13434 1 0 decap_w0
xfeed_13433 1 0 decap_w0
xfeed_13432 1 0 decap_w0
xfeed_12909 1 0 decap_w0
xfeed_12908 1 0 decap_w0
xfeed_12907 1 0 decap_w0
xfeed_12906 1 0 decap_w0
xfeed_12905 1 0 decap_w0
xfeed_12904 1 0 decap_w0
xfeed_12903 1 0 decap_w0
xfeed_12902 1 0 decap_w0
xfeed_12901 1 0 decap_w0
xfeed_12900 1 0 decap_w0
xfeed_7239 1 0 tie
xfeed_7238 1 0 decap_w0
xfeed_7237 1 0 decap_w0
xfeed_7236 1 0 decap_w0
xfeed_7235 1 0 decap_w0
xfeed_7234 1 0 decap_w0
xfeed_7233 1 0 decap_w0
xfeed_7232 1 0 decap_w0
xfeed_7231 1 0 decap_w0
xfeed_7230 1 0 decap_w0
xfeed_6709 1 0 decap_w0
xfeed_6708 1 0 decap_w0
xfeed_6707 1 0 decap_w0
xfeed_6706 1 0 decap_w0
xfeed_6705 1 0 decap_w0
xfeed_6704 1 0 decap_w0
xfeed_6703 1 0 decap_w0
xfeed_6702 1 0 decap_w0
xfeed_6701 1 0 decap_w0
xfeed_6700 1 0 decap_w0
xspare_feed_320 1 0 tie
xspare_feed_321 1 0 decap_w0
xspare_feed_322 1 0 tie
xspare_feed_323 1 0 tie
xfeed_30289 1 0 decap_w0
xfeed_30288 1 0 decap_w0
xfeed_30287 1 0 decap_w0
xfeed_30286 1 0 decap_w0
xfeed_30285 1 0 decap_w0
xfeed_30284 1 0 decap_w0
xfeed_30283 1 0 decap_w0
xfeed_30282 1 0 decap_w0
xfeed_30281 1 0 decap_w0
xfeed_30280 1 0 decap_w0
xfeed_29209 1 0 decap_w0
xfeed_29208 1 0 decap_w0
xfeed_29207 1 0 decap_w0
xfeed_29206 1 0 decap_w0
xfeed_29205 1 0 decap_w0
xfeed_29204 1 0 decap_w0
xfeed_29203 1 0 decap_w0
xfeed_29202 1 0 decap_w0
xfeed_29201 1 0 decap_w0
xfeed_29200 1 0 decap_w0
xfeed_28599 1 0 decap_w0
xfeed_28598 1 0 decap_w0
xfeed_28597 1 0 decap_w0
xfeed_28596 1 0 decap_w0
xfeed_28595 1 0 decap_w0
xfeed_28594 1 0 decap_w0
xfeed_28593 1 0 decap_w0
xfeed_28592 1 0 decap_w0
xfeed_28591 1 0 decap_w0
xfeed_28590 1 0 decap_w0
xfeed_24289 1 0 decap_w0
xfeed_24288 1 0 decap_w0
xfeed_24287 1 0 decap_w0
xfeed_24286 1 0 decap_w0
xfeed_24285 1 0 decap_w0
xfeed_24284 1 0 decap_w0
xfeed_24283 1 0 decap_w0
xfeed_24282 1 0 decap_w0
xfeed_24281 1 0 decap_w0
xfeed_24280 1 0 decap_w0
xfeed_23759 1 0 decap_w0
xfeed_23758 1 0 decap_w0
xfeed_23757 1 0 decap_w0
xfeed_23756 1 0 decap_w0
xfeed_23755 1 0 decap_w0
xfeed_23754 1 0 decap_w0
xfeed_23753 1 0 decap_w0
xfeed_23752 1 0 decap_w0
xfeed_23751 1 0 decap_w0
xfeed_23750 1 0 decap_w0
xfeed_299 1 0 decap_w0
xfeed_298 1 0 decap_w0
xfeed_297 1 0 decap_w0
xfeed_296 1 0 decap_w0
xfeed_295 1 0 decap_w0
xfeed_294 1 0 decap_w0
xfeed_293 1 0 decap_w0
xfeed_292 1 0 decap_w0
xfeed_291 1 0 decap_w0
xfeed_290 1 0 decap_w0
xspare_feed_324 1 0 decap_w0
xspare_feed_325 1 0 tie
xspare_feed_326 1 0 tie
xspare_feed_327 1 0 decap_w0
xspare_feed_328 1 0 tie
xspare_feed_329 1 0 tie
xfeed_1780 1 0 decap_w0
xfeed_1781 1 0 decap_w0
xfeed_1782 1 0 decap_w0
xfeed_1783 1 0 decap_w0
xfeed_1784 1 0 decap_w0
xfeed_1785 1 0 decap_w0
xfeed_1786 1 0 decap_w0
xfeed_1787 1 0 decap_w0
xfeed_1788 1 0 decap_w0
xfeed_1789 1 0 decap_w0
xfeed_18289 1 0 decap_w0
xfeed_18288 1 0 decap_w0
xfeed_18287 1 0 decap_w0
xfeed_18286 1 0 decap_w0
xfeed_18285 1 0 decap_w0
xfeed_18284 1 0 decap_w0
xfeed_18283 1 0 decap_w0
xfeed_18282 1 0 decap_w0
xfeed_18281 1 0 decap_w0
xfeed_18280 1 0 decap_w0
xfeed_17759 1 0 decap_w0
xfeed_17758 1 0 decap_w0
xfeed_17757 1 0 decap_w0
xfeed_17756 1 0 decap_w0
xfeed_17755 1 0 decap_w0
xfeed_17754 1 0 decap_w0
xfeed_17753 1 0 decap_w0
xfeed_17752 1 0 decap_w0
xfeed_17751 1 0 decap_w0
xfeed_17750 1 0 decap_w0
xfeed_13449 1 0 decap_w0
xfeed_13448 1 0 decap_w0
xfeed_13447 1 0 decap_w0
xfeed_13446 1 0 decap_w0
xfeed_13445 1 0 decap_w0
xfeed_13444 1 0 decap_w0
xfeed_13443 1 0 decap_w0
xfeed_13442 1 0 decap_w0
xfeed_13441 1 0 decap_w0
xfeed_13440 1 0 decap_w0
xfeed_12919 1 0 decap_w0
xfeed_12918 1 0 decap_w0
xfeed_12917 1 0 decap_w0
xfeed_12916 1 0 decap_w0
xfeed_12915 1 0 decap_w0
xfeed_12914 1 0 decap_w0
xfeed_12913 1 0 decap_w0
xfeed_12912 1 0 decap_w0
xfeed_12911 1 0 decap_w0
xfeed_12910 1 0 decap_w0
xfeed_7249 1 0 decap_w0
xfeed_7248 1 0 decap_w0
xfeed_7247 1 0 decap_w0
xfeed_7246 1 0 decap_w0
xfeed_7245 1 0 decap_w0
xfeed_7244 1 0 decap_w0
xfeed_7243 1 0 decap_w0
xfeed_7242 1 0 decap_w0
xfeed_7241 1 0 decap_w0
xfeed_7240 1 0 decap_w0
xfeed_6716 1 0 decap_w0
xfeed_6715 1 0 decap_w0
xfeed_6714 1 0 decap_w0
xfeed_6713 1 0 decap_w0
xfeed_6712 1 0 decap_w0
xfeed_6711 1 0 decap_w0
xfeed_6710 1 0 decap_w0
xfeed_2409 1 0 decap_w0
xfeed_2408 1 0 decap_w0
xfeed_2407 1 0 decap_w0
xfeed_2406 1 0 decap_w0
xfeed_2405 1 0 decap_w0
xfeed_2404 1 0 decap_w0
xfeed_2403 1 0 decap_w0
xfeed_2402 1 0 decap_w0
xfeed_2401 1 0 decap_w0
xfeed_2400 1 0 decap_w0
xspare_feed_330 1 0 decap_w0
xfeed_30299 1 0 decap_w0
xfeed_30298 1 0 decap_w0
xfeed_30297 1 0 decap_w0
xfeed_30296 1 0 decap_w0
xfeed_30295 1 0 decap_w0
xfeed_30294 1 0 decap_w0
xfeed_30293 1 0 decap_w0
xfeed_30292 1 0 decap_w0
xfeed_30291 1 0 decap_w0
xfeed_30290 1 0 decap_w0
xfeed_29219 1 0 decap_w0
xfeed_29218 1 0 decap_w0
xfeed_29217 1 0 decap_w0
xfeed_29216 1 0 decap_w0
xfeed_29215 1 0 decap_w0
xfeed_29214 1 0 decap_w0
xfeed_29213 1 0 decap_w0
xfeed_29212 1 0 decap_w0
xfeed_29211 1 0 decap_w0
xfeed_29210 1 0 decap_w0
xfeed_24299 1 0 decap_w0
xfeed_24298 1 0 decap_w0
xfeed_24297 1 0 decap_w0
xfeed_24296 1 0 decap_w0
xfeed_24295 1 0 decap_w0
xfeed_24294 1 0 decap_w0
xfeed_24293 1 0 decap_w0
xfeed_24292 1 0 decap_w0
xfeed_24291 1 0 decap_w0
xfeed_24290 1 0 decap_w0
xfeed_23769 1 0 decap_w0
xfeed_23768 1 0 decap_w0
xfeed_23767 1 0 decap_w0
xfeed_23766 1 0 decap_w0
xfeed_23765 1 0 decap_w0
xfeed_23764 1 0 decap_w0
xfeed_23763 1 0 decap_w0
xfeed_23762 1 0 decap_w0
xfeed_23761 1 0 decap_w0
xfeed_23760 1 0 decap_w0
xfeed_6719 1 0 decap_w0
xfeed_6718 1 0 decap_w0
xfeed_6717 1 0 decap_w0
xspare_feed_331 1 0 tie
xspare_feed_332 1 0 tie
xspare_feed_333 1 0 decap_w0
xspare_feed_334 1 0 tie
xspare_feed_335 1 0 tie
xfeed_1790 1 0 decap_w0
xfeed_1791 1 0 decap_w0
xfeed_1792 1 0 decap_w0
xfeed_1793 1 0 decap_w0
xfeed_1794 1 0 decap_w0
xfeed_1795 1 0 decap_w0
xfeed_1796 1 0 decap_w0
xfeed_1797 1 0 decap_w0
xfeed_1798 1 0 decap_w0
xfeed_1799 1 0 decap_w0
xfeed_18299 1 0 decap_w0
xfeed_18298 1 0 decap_w0
xfeed_18297 1 0 decap_w0
xfeed_18296 1 0 decap_w0
xfeed_18295 1 0 decap_w0
xfeed_18294 1 0 decap_w0
xfeed_18293 1 0 decap_w0
xfeed_18292 1 0 decap_w0
xfeed_18291 1 0 decap_w0
xfeed_18290 1 0 decap_w0
xfeed_17769 1 0 decap_w0
xfeed_17768 1 0 decap_w0
xfeed_17767 1 0 decap_w0
xfeed_17766 1 0 decap_w0
xfeed_17765 1 0 decap_w0
xfeed_17764 1 0 decap_w0
xfeed_17763 1 0 decap_w0
xfeed_17762 1 0 decap_w0
xfeed_17761 1 0 decap_w0
xfeed_17760 1 0 decap_w0
xfeed_13459 1 0 decap_w0
xfeed_13458 1 0 decap_w0
xfeed_13457 1 0 decap_w0
xfeed_13456 1 0 decap_w0
xfeed_13455 1 0 decap_w0
xfeed_13454 1 0 decap_w0
xfeed_13453 1 0 decap_w0
xfeed_13452 1 0 decap_w0
xfeed_13451 1 0 decap_w0
xfeed_13450 1 0 decap_w0
xfeed_12929 1 0 decap_w0
xfeed_12928 1 0 decap_w0
xfeed_12927 1 0 decap_w0
xfeed_12926 1 0 decap_w0
xfeed_12925 1 0 decap_w0
xfeed_12924 1 0 decap_w0
xfeed_12923 1 0 decap_w0
xfeed_12922 1 0 decap_w0
xfeed_12921 1 0 decap_w0
xfeed_12920 1 0 decap_w0
xfeed_7259 1 0 decap_w0
xfeed_7258 1 0 decap_w0
xfeed_7257 1 0 decap_w0
xfeed_7256 1 0 decap_w0
xfeed_7255 1 0 decap_w0
xfeed_7254 1 0 decap_w0
xfeed_7253 1 0 decap_w0
xfeed_7252 1 0 decap_w0
xfeed_7251 1 0 decap_w0
xfeed_7250 1 0 decap_w0
xfeed_6723 1 0 decap_w0
xfeed_6722 1 0 decap_w0
xfeed_6721 1 0 decap_w0
xfeed_6720 1 0 decap_w0
xfeed_2419 1 0 decap_w0
xfeed_2418 1 0 decap_w0
xfeed_2417 1 0 decap_w0
xfeed_2416 1 0 decap_w0
xfeed_2415 1 0 decap_w0
xfeed_2414 1 0 decap_w0
xfeed_2413 1 0 decap_w0
xfeed_2412 1 0 decap_w0
xfeed_2411 1 0 decap_w0
xfeed_2410 1 0 decap_w0
xfeed_29229 1 0 decap_w0
xfeed_29228 1 0 decap_w0
xfeed_29227 1 0 decap_w0
xfeed_29226 1 0 decap_w0
xfeed_29225 1 0 decap_w0
xfeed_29224 1 0 decap_w0
xfeed_29223 1 0 decap_w0
xfeed_29222 1 0 decap_w0
xfeed_29221 1 0 decap_w0
xfeed_29220 1 0 decap_w0
xfeed_23779 1 0 decap_w0
xfeed_23778 1 0 decap_w0
xfeed_23777 1 0 decap_w0
xfeed_23776 1 0 decap_w0
xfeed_23775 1 0 decap_w0
xfeed_23774 1 0 decap_w0
xfeed_23773 1 0 decap_w0
xfeed_23772 1 0 decap_w0
xfeed_23771 1 0 decap_w0
xfeed_23770 1 0 decap_w0
xfeed_6729 1 0 decap_w0
xfeed_6728 1 0 decap_w0
xfeed_6727 1 0 decap_w0
xfeed_6726 1 0 decap_w0
xfeed_6725 1 0 decap_w0
xfeed_6724 1 0 decap_w0
xfeed_17779 1 0 decap_w0
xfeed_17778 1 0 decap_w0
xfeed_17777 1 0 decap_w0
xfeed_17776 1 0 decap_w0
xfeed_17775 1 0 decap_w0
xfeed_17774 1 0 decap_w0
xfeed_17773 1 0 decap_w0
xfeed_17772 1 0 decap_w0
xfeed_17771 1 0 decap_w0
xfeed_17770 1 0 decap_w0
xfeed_13469 1 0 decap_w0
xfeed_13468 1 0 decap_w0
xfeed_13467 1 0 decap_w0
xfeed_13466 1 0 decap_w0
xfeed_13465 1 0 decap_w0
xfeed_13464 1 0 decap_w0
xfeed_13463 1 0 decap_w0
xfeed_13462 1 0 decap_w0
xfeed_13461 1 0 decap_w0
xfeed_13460 1 0 decap_w0
xfeed_12939 1 0 decap_w0
xfeed_12938 1 0 decap_w0
xfeed_12937 1 0 decap_w0
xfeed_12936 1 0 decap_w0
xfeed_12935 1 0 decap_w0
xfeed_12934 1 0 decap_w0
xfeed_12933 1 0 decap_w0
xfeed_12932 1 0 decap_w0
xfeed_12931 1 0 decap_w0
xfeed_12930 1 0 decap_w0
xfeed_7269 1 0 decap_w0
xfeed_7268 1 0 decap_w0
xfeed_7267 1 0 decap_w0
xfeed_7266 1 0 decap_w0
xfeed_7265 1 0 decap_w0
xfeed_7264 1 0 decap_w0
xfeed_7263 1 0 decap_w0
xfeed_7262 1 0 decap_w0
xfeed_7261 1 0 decap_w0
xfeed_7260 1 0 decap_w0
xfeed_6730 1 0 decap_w0
xfeed_2429 1 0 decap_w0
xfeed_2428 1 0 decap_w0
xfeed_2427 1 0 decap_w0
xfeed_2426 1 0 decap_w0
xfeed_2425 1 0 decap_w0
xfeed_2424 1 0 decap_w0
xfeed_2423 1 0 decap_w0
xfeed_2422 1 0 decap_w0
xfeed_2421 1 0 decap_w0
xfeed_2420 1 0 decap_w0
.ends expmob1_r
